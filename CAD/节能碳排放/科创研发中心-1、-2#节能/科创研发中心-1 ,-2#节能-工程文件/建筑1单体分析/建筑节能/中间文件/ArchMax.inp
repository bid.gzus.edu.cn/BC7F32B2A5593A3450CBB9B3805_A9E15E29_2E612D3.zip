 W=2.7 H=5.4 AZ=249.88 N-T RM02049 ..
D02007 I-W CONS DR1 X=93.983 Y=0
 A=1.68 N-T RM02049 ..
B02035 I-W CONS COMMBOARD1 X=93.702 Y=-1.989 Z=0
 A=3.24 AZ=159.88 TILT=180 N-T RM01022 ..

RM02023=SPACE S-C=CondType1
 A=23.53  V=127.062  AZ=0   Z=5.4 ..
AW02267 E-W CONS EW1 X=83.24 Y=3.604
 W=2.8 H=5.4 AZ=249.88 S-S YES ..
I02011 I-W CONS IW1 X=92.232 Y=5.513
 W=1.5 H=5.4 AZ=339.88 N-T RM02024 ..
D02002 I-W CONS DR1 X=91.231 Y=0
 A=1.68 N-T RM02024 ..
I02014 I-W CONS IW1 X=90.376 Y=6.218
 W=1.3 H=5.4 AZ=249.88 N-T RM02024 ..
I02003 I-W CONS IW1 X=90.376 Y=6.218
 W=7.6 H=5.4 AZ=339.88 N-T RM02049 ..
I02006 I-W CONS IW1 X=90.612 Y=3.322
 W=2.275 H=5.4 AZ=159.88 N-T RM02049 ..
D02001 I-W CONS DR1 X=91.767 Y=0
 A=2.1 N-T RM02049 ..
I02010 I-W CONS IW1 X=92.232 Y=5.513
 W=1.5 H=5.4 AZ=249.88 N-T RM02049 ..
B02036 I-W CONS COMMBOARD1 X=84.485 Y=1.078 Z=0
 A=22.689 AZ=159.88 TILT=180 N-T RM01023 ..
B02083 E-W CONS ABOARD1 X=84.203 Y=0.975 Z=0
 W=2.8 H=0.3 AZ=69.88 TILT=180 ..

RM02024=SPACE S-C=CondType1
 A=1.95  V=10.53  AZ=0   Z=5.4 ..
I02013 I-W CONS IW1 X=91.785 Y=6.734
 W=1.5 H=5.4 AZ=339.88 N-T RM02049 ..
I02019 I-W CONS IW1 X=91.785 Y=6.734
 W=1.3 H=5.4 AZ=249.88 N-T RM02049 ..
B02037 I-W CONS COMMBOARD1 X=90.823 Y=4.997 Z=0
 A=1.95 AZ=159.88 TILT=180 N-T RM01024 ..

RM02025=SPACE S-C=CondType1
 A=3.915  V=21.141  AZ=0   Z=5.4 ..
I02141 I-W CONS IW1 X=97.581 Y=-9.088
 W=1.35 H=5.4 AZ=159.88 N-T RM02049 ..
I02140 I-W CONS IW1 X=98.578 Y=-11.811
 W=1.35 H=5.4 AZ=159.88 N-T RM02049 ..
I02142 I-W CONS IW1 X=98.848 Y=-8.623
 W=2.9 H=5.4 AZ=249.88 N-T RM02049 ..
B02038 I-W CONS COMMBOARD1 X=98.578 Y=-11.811 Z=0
 A=3.915 AZ=159.88 TILT=180 N-T RM01025 ..

RM02026=SPACE S-C=CondType1
 A=3.915  V=21.141  AZ=0   Z=5.4 ..
I02137 I-W CONS IW1 X=128.755 Y=2.333
 W=1.35 H=5.4 AZ=339.88 N-T RM02049 ..
I02138 I-W CONS IW1 X=127.487 Y=1.868
 W=2.9 H=5.4 AZ=249.88 N-T RM02049 ..
I02136 I-W CONS IW1 X=129.752 Y=-0.39
 W=1.35 H=5.4 AZ=339.88 N-T RM02049 ..
I02217 I-W CONS IW1 X=128.755 Y=2.333
 W=2.9 H=5.4 AZ=249.88 N-T RM02027 ..
B02039 I-W CONS COMMBOARD1 X=128.485 Y=-0.855 Z=0
 A=3.915 AZ=159.88 TILT=180 N-T RM01025 ..

RM02027=SPACE S-C=CondType1
 A=38.72  V=209.088  AZ=0   Z=5.4 ..
I02214 I-W CONS IW1 X=132.886 Y=3.846
 W=4.4 H=5.4 AZ=339.88 N-T RM02049 ..
D02041 I-W CONS DR1 X=129.805 Y=0
 A=4.62 N-T RM02049 ..
I02135 I-W CONS IW1 X=129.752 Y=-0.39
 W=5.9 H=5.4 AZ=249.88 N-T RM02049 ..
I02109 I-W CONS IW1 X=135.913 Y=-4.417
 W=4.4 H=5.4 AZ=339.88 N-T RM02049 ..
I02215 I-W CONS IW1 X=132.886 Y=3.846
 W=8.8 H=5.4 AZ=249.88 N-T RM02028 ..
B02010 I-W CONS COMMBOARD1 X=131.842 Y=-5.802 Z=0
 A=8.82 AZ=159.88 TILT=180 N-T RM01026 ..
B02041 I-W CONS COMMBOARD1 X=131.782 Y=-5.93 Z=0
 A=38.72 AZ=159.88 TILT=180 N-T RM01026 ..

RM02028=SPACE S-C=CondType1
 A=38.72  V=209.088  AZ=0   Z=5.4 ..
AW02110 E-W CONS EW1 X=140.045 Y=-2.903
 W=8.8 H=5.4 AZ=69.88 S-S YES ..
I02219 I-W CONS IW1 X=137.018 Y=5.36
 W=4.4 H=5.4 AZ=339.88 N-T RM02049 ..
D02042 I-W CONS DR1 X=133.978 Y=0
 A=4.62 N-T RM02049 ..
I02218 I-W CONS IW1 X=140.045 Y=-2.903
 W=4.4 H=5.4 AZ=339.88 N-T RM02049 ..
B02009 I-W CONS COMMBOARD1 X=135.973 Y=-4.289 Z=0
 A=8.82 AZ=159.88 TILT=180 N-T RM01027 ..
B02042 I-W CONS COMMBOARD1 X=135.913 Y=-4.417 Z=0
 A=38.72 AZ=159.88 TILT=180 N-T RM01027 ..

RM02029=SPACE S-C=CondType1
 A=4.455  V=24.057  AZ=0   Z=5.4 ..
AW02181 E-W CONS EW1 X=134.266 Y=12.872
 W=2.7 H=5.4 AZ=69.88 S-S YES ..
I02208 I-W CONS IW1 X=133.337 Y=15.407
 W=1.65 H=5.4 AZ=339.88 N-T RM02030 ..
I02149 I-W CONS IW1 X=132.717 Y=12.304
 W=2.7 H=5.4 AZ=69.88 N-T RM02049 ..
I02182 I-W CONS IW1 X=134.266 Y=12.872
 W=1.65 H=5.4 AZ=339.88 N-T RM02049 ..
B02046 I-W CONS COMMBOARD1 X=132.717 Y=12.304 Z=0
 A=4.455 AZ=159.88 TILT=180 N-T RM01031 ..

RM02030=SPACE S-C=CondType1
 A=4.2  V=22.68  AZ=0   Z=5.4 ..
AW02209 E-W CONS EW1 X=133.337 Y=15.407
 W=1.4 H=5.4 AZ=69.88 S-S YES ..
D02040 Door CONS DR1 X=0.3 Y=0.001
 W=0.799 H=2.099 ..
I02129 I-W CONS IW1 X=132.856 Y=16.721
 W=3 H=5.4 AZ=339.88 N-T RM02031 ..
I02206 I-W CONS IW1 X=130.52 Y=14.375
 W=1.4 H=5.4 AZ=69.88 N-T RM02049 ..
I02148 I-W CONS IW1 X=131.788 Y=14.839
 W=1.35 H=5.4 AZ=339.88 N-T RM02049 ..
B02043 I-W CONS COMMBOARD1 X=130.52 Y=14.375 Z=0
 A=4.2 AZ=159.88 TILT=180 N-T RM01028 ..

RM02031=SPACE S-C=CondType1
 A=5.1  V=27.54  AZ=0   Z=5.4 ..
AW02128 E-W CONS EW1 X=132.856 Y=16.721
 W=1.7 H=5.4 AZ=69.88 S-S YES ..
D02031 Door CONS DR1 X=0.45 Y=0.001
 W=0.799 H=2.099 ..
I02212 I-W CONS IW1 X=132.271 Y=18.318
 W=3 H=5.4 AZ=339.88 N-T RM02032 ..
I02127 I-W CONS IW1 X=130.039 Y=15.689
 W=1.7 H=5.4 AZ=69.88 N-T RM02049 ..
B02044 I-W CONS COMMBOARD1 X=130.039 Y=15.689 Z=0
 A=5.1 AZ=159.88 TILT=180 N-T RM01029 ..

RM02032=SPACE S-C=CondType1
 A=9  V=48.6  AZ=0   Z=5.4 ..
AW02211 E-W CONS EW1 X=132.271 Y=18.318
 W=3 H=5.4 AZ=69.88 S-S YES ..
I02213 I-W CONS IW1 X=131.239 Y=21.134
 W=3 H=5.4 AZ=339.88 N-T RM02049 ..
I02207 I-W CONS IW1 X=129.454 Y=17.286
 W=3 H=5.4 AZ=69.88 N-T RM02049 ..
B02045 I-W CONS COMMBOARD1 X=129.454 Y=17.286 Z=0
 A=9 AZ=159.88 TILT=180 N-T RM01030 ..

RM02033=SPACE S-C=CondType1
 A=2.859  V=15.439  AZ=0   Z=5.4 ..
AW02113 E-W CONS EW1 X=153.962 Y=10.357
 W=1.3 H=5.4 AZ=256.907 S-S YES ..
I02193 I-W CONS IW1 X=153.962 Y=10.357
 W=2.2 H=5.4 AZ=166.922 N-T RM02050 ..
I02114 I-W CONS IW1 X=154.256 Y=9.091
 W=2.2 H=5.4 AZ=166.922 N-T RM02035 ..
I02059 I-W CONS IW1 X=156.104 Y=10.855
 W=1.3 H=5.4 AZ=256.922 N-T RM02035 ..
B02049 I-W CONS COMMBOARD1 X=154.349 Y=8.838 Z=0
 A=2.859 AZ=159.88 TILT=180 N-T RM01033 ..

RM02034=SPACE S-C=CondType1
 A=5.163  V=27.878  AZ=0   Z=5.4 ..
AW02147 E-W CONS EW1 X=151.484 Y=21.023
 W=2.949 H=5.4 AZ=256.922 S-S YES ..
I02199 I-W CONS IW1 X=151.484 Y=21.023
 W=1.75 H=5.4 AZ=166.922 N-T RM02036 ..
I02180 I-W CONS IW1 X=152.152 Y=18.15
 W=1.75 H=5.4 AZ=166.922 N-T RM02050 ..
I02131 I-W CONS IW1 X=153.188 Y=21.419
 W=2.95 H=5.4 AZ=256.922 N-T RM02050 ..
B02056 I-W CONS COMMBOARD1 X=152.225 Y=17.949 Z=0
 A=5.162 AZ=159.88 TILT=180 N-T RM01039 ..

RM02035=SPACE S-C=CondType1
 A=35.859  V=193.638  AZ=0   Z=5.4 ..
AW02097 E-W CONS EW1 X=154.256 Y=9.091
 W=7.501 H=5.4 AZ=256.922 S-S YES ..
I02056 I-W CONS IW1 X=156.104 Y=10.855
 W=2.201 H=5.4 AZ=166.922 N-T RM02050 ..
D02014 I-W CONS DR1 X=156.468 Y=0
 A=4.62 N-T RM02050 ..
I02112 I-W CONS IW1 X=155.953 Y=1.785
 W=4.4 H=5.4 AZ=166.922 N-T RM02050 ..
I02058 I-W CONS IW1 X=158.564 Y=9.989
 W=7.4 H=5.4 AZ=256.922 N-T RM02040 ..
I02060 I-W CONS IW1 X=158.248 Y=11.352
 W=1.4 H=5.4 AZ=256.922 N-T RM02040 ..
B02002 I-W CONS COMMBOARD1 X=156.205 Y=1.422 Z=0
 A=8.82 AZ=159.88 TILT=180 N-T RM01032 ..
B02048 I-W CONS COMMBOARD1 X=156.138 Y=1.279 Z=0
 A=32.998 AZ=159.88 TILT=180 N-T RM01032 ..
B02050 I-W CONS COMMBOARD1 X=156.492 Y=9.335 Z=0
 A=2.86 AZ=159.88 TILT=180 N-T RM01033 ..

RM02036=SPACE S-C=CondType1
 A=4.651  V=25.114  AZ=0   Z=5.4 ..
AW02037 E-W CONS EW1 X=151.144 Y=22.484
 W=1.5 H=5.4 AZ=256.922 S-S YES ..
D02011 Door CONS DR1 X=0.6 Y=0.001
 W=0.799 H=2.099 ..
I02038 I-W CONS IW1 X=151.144 Y=22.484
 W=3.1 H=5.4 AZ=166.922 N-T RM02037 ..
I02146 I-W CONS IW1 X=153.188 Y=21.419
 W=1.35 H=5.4 AZ=166.922 N-T RM02050 ..
I02036 I-W CONS IW1 X=154.164 Y=23.186
 W=1.5 H=5.4 AZ=256.922 N-T RM02050 ..
B02051 I-W CONS COMMBOARD1 X=151.61 Y=20.678 Z=0
 A=4.5 AZ=159.88 TILT=180 N-T RM01034 ..
B02059 I-W CONS COMMBOARD1 X=154.411 Y=21.69 Z=0
 A=0.15 AZ=159.88 TILT=180 N-T RM01039 ..

RM02037=SPACE S-C=CondType1
 A=4.185  V=22.601  AZ=0   Z=5.4 ..
AW02198 E-W CONS EW1 X=150.839 Y=23.799
 W=1.35 H=5.4 AZ=256.922 S-S YES ..
D02035 Door CONS DR1 X=0.45 Y=0.001
 W=0.799 H=2.099 ..
I02200 I-W CONS IW1 X=150.839 Y=23.799
 W=3.099 H=5.4 AZ=166.922 N-T RM02038 ..
I02130 I-W CONS IW1 X=153.858 Y=24.501
 W=1.35 H=5.4 AZ=256.922 N-T RM02050 ..
B02052 I-W CONS COMMBOARD1 X=151.271 Y=22.139 Z=0
 A=4.05 AZ=159.88 TILT=180 N-T RM01035 ..
B02060 I-W CONS COMMBOARD1 X=154.071 Y=23.152 Z=0
 A=0.135 AZ=159.88 TILT=180 N-T RM01039 ..

RM02038=SPACE S-C=CondType1
 A=9.297  V=50.204  AZ=0   Z=5.4 ..
AW02202 E-W CONS EW1 X=150.161 Y=26.721
 W=3 H=5.4 AZ=256.922 S-S YES ..
I02188 I-W CONS IW1 X=150.161 Y=26.721
 W=3.099 H=5.4 AZ=166.922 N-T RM02039 ..
I02081 I-W CONS IW1 X=153.18 Y=27.423
 W=3 H=5.4 AZ=256.922 N-T RM02050 ..
B02053 I-W CONS COMMBOARD1 X=150.966 Y=23.454 Z=0
 A=8.997 AZ=159.88 TILT=180 N-T RM01036 ..
B02061 I-W CONS COMMBOARD1 X=153.765 Y=24.467 Z=0
 A=0.299 AZ=159.88 TILT=180 N-T RM01039 ..

RM02039=SPACE S-C=CondType1
 A=3.411  V=18.417  AZ=0   Z=5.4 ..
AW02082 E-W CONS EW1 X=149.911 Y=27.793
 W=1.1 H=5.4 AZ=256.922 S-S YES ..
D02018 Door CONS DR1 X=0.134 Y=0.001
 W=0.799 H=2.099 ..
I02083 I-W CONS IW1 X=149.911 Y=27.793
 W=3.1 H=5.4 AZ=166.922 N-T RM02050 ..
I02201 I-W CONS IW1 X=152.931 Y=28.494
 W=1.1 H=5.4 AZ=256.922 N-T RM02050 ..
B02054 I-W CONS COMMBOARD1 X=150.287 Y=26.376 Z=0
 A=3.3 AZ=159.88 TILT=180 N-T RM01037 ..
B02062 I-W CONS COMMBOARD1 X=153.087 Y=27.389 Z=0
 A=0.11 AZ=159.88 TILT=180 N-T RM01039 ..

RM02040=SPACE S-C=CondType1
 A=38.723  V=209.104  AZ=0   Z=5.4 ..
I02057 I-W CONS IW1 X=158.248 Y=11.352
 W=4.4 H=5.4 AZ=166.922 N-T RM02050 ..
D02015 I-W CONS DR1 X=160.222 Y=0
 A=4.62 N-T RM02050 ..
I02055 I-W CONS IW1 X=160.239 Y=2.781
 W=4.4 H=5.4 AZ=166.922 N-T RM02050 ..
I02192 I-W CONS IW1 X=162.534 Y=12.348
 W=8.8 H=5.4 AZ=256.922 N-T RM02050 ..
R02005 ROOF CONS RF2 X=160.425 Y=2.274 Z=5.4
 W=4.4 H=0.001 AZ=159.88 TILT=0 ..
B02011 I-W CONS COMMBOARD1 X=160.491 Y=2.418 Z=0
 A=8.82 AZ=159.88 TILT=180 N-T RM01038 ..
B02055 I-W CONS COMMBOARD1 X=160.424 Y=2.275 Z=0
 A=38.721 AZ=159.88 TILT=180 N-T RM01038 ..

RM02041=SPACE S-C=CondType1
 A=5.22  V=28.188  AZ=0   Z=5.4 ..
I02046 I-W CONS IW1 X=178.261 Y=41.873
 W=1.45 H=5.4 AZ=166.922 N-T RM02050 ..
I02143 I-W CONS IW1 X=178.985 Y=38.756
 W=3.2 H=5.4 AZ=76.922 N-T RM02050 ..
I02164 I-W CONS IW1 X=179.076 Y=38.366
 W=0.4 H=5.4 AZ=76.922 N-T RM02050 ..
I02144 I-W CONS IW1 X=179.076 Y=38.366
 W=1.45 H=5.4 AZ=166.922 N-T RM02050 ..
I02145 I-W CONS IW1 X=180.488 Y=38.694
 W=3.6 H=5.4 AZ=76.922 N-T RM02050 ..
B02057 I-W CONS COMMBOARD1 X=179.137 Y=38.199 Z=0
 A=5.22 AZ=159.88 TILT=180 N-T RM01039 ..

RM02042=SPACE S-C=CondType1
 A=11.999  V=64.796  AZ=0   Z=5.4 ..
AW02027 E-W CONS EW1 X=200.469 Y=47.032
 W=3.2 H=5.4 AZ=346.922 S-S YES ..
I02028 I-W CONS IW1 X=198.201 Y=42.655
 W=3.75 H=5.4 AZ=76.922 N-T RM02050 ..
I02197 I-W CONS IW1 X=198.201 Y=42.655
 W=3.199 H=5.4 AZ=166.922 N-T RM02050 ..
I02196 I-W CONS IW1 X=201.318 Y=43.379
 W=3.75 H=5.4 AZ=76.922 N-T RM02050 ..
B02069 I-W CONS COMMBOARD1 X=198.336 Y=42.287 Z=0
 A=11.999 AZ=159.88 TILT=180 N-T RM01044 ..

RM02043=SPACE S-C=CondType1
 A=40.391  V=218.112  AZ=0   Z=5.4 ..
AW02157 E-W CONS EW1 X=215.518 Y=6.999
 W=8.6 H=5.4 AZ=76.922 S-S YES ..
WIN02032  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-4
 X=5.3 Y=0.9
 W=2.399 H=0.999 ..
I02105 I-W CONS IW1 X=209.286 Y=14.381
 W=4.4 H=5.4 AZ=166.922 N-T RM02044 ..
I02102 I-W CONS IW1 X=208.313 Y=14.154
 W=0.999 H=5.4 AZ=166.922 N-T RM02050 ..
I02101 I-W CONS IW1 X=208.889 Y=11.67
 W=2.55 H=5.4 AZ=76.922 N-T RM02050 ..
D02023 I-W CONS DR1 X=207.925 Y=0
 A=4.515 N-T RM02050 ..
I02100 I-W CONS IW1 X=208.889 Y=11.67
 W=1 H=5.4 AZ=166.922 N-T RM02050 ..
I02106 I-W CONS IW1 X=211.233 Y=6.003
 W=6.051 H=5.4 AZ=76.922 N-T RM02050 ..
I02108 I-W CONS IW1 X=211.233 Y=6.003
 W=4.4 H=5.4 AZ=166.922 N-T RM02050 ..
R02001 ROOF CONS RF1 X=211.182 Y=5.41 Z=5.4
 W=8.6 H=4.571 AZ=159.88 TILT=0 ..
B02065 I-W CONS COMMBOARD1 X=208.931 Y=11.555 Z=0
 A=2.549 AZ=159.88 TILT=180 N-T RM01042 ..
B02070 I-W CONS COMMBOARD1 X=211.418 Y=5.497 Z=0
 A=37.841 AZ=159.88 TILT=180 N-T RM01045 ..

RM02044=SPACE S-C=CondType1
 A=5.72  V=30.887  AZ=0   Z=5.4 ..
AW02190 E-W CONS EW1 X=213.572 Y=15.376
 W=1.3 H=5.4 AZ=76.922 S-S YES ..
I02158 I-W CONS IW1 X=208.992 Y=15.647
 W=4.4 H=5.4 AZ=166.922 N-T RM02045 ..
I02103 I-W CONS IW1 X=209.286 Y=14.381
 W=1.3 H=5.4 AZ=76.922 N-T RM02050 ..
B02071 I-W CONS COMMBOARD1 X=209.472 Y=13.874 Z=0
 A=5.719 AZ=159.88 TILT=180 N-T RM01046 ..

RM02045=SPACE S-C=CondType1
 A=31.241  V=168.704  AZ=0   Z=5.4 ..
AW02191 E-W CONS EW1 X=213.279 Y=16.642
 W=7.101 H=5.4 AZ=76.922 S-S YES ..
I02104 I-W CONS IW1 X=207.386 Y=22.562
 W=4.4 H=5.4 AZ=166.922 N-T RM02046 ..
I02099 I-W CONS IW1 X=208.992 Y=15.647
 W=7.1 H=5.4 AZ=76.922 N-T RM02050 ..
B02003 I-W CONS COMMBOARD1 X=209.244 Y=15.283 Z=0
 A=8.82 AZ=159.88 TILT=180 N-T RM01047 ..
B02072 I-W CONS COMMBOARD1 X=209.178 Y=15.14 Z=0
 A=28.491 AZ=159.88 TILT=180 N-T RM01047 ..
B02094 E-W CONS ABOARD1 X=211.361 Y=20.538 Z=0
 W=2.75 H=1 AZ=69.88 TILT=180 ..

RM02046=SPACE S-C=CondType1
 A=39.51  V=213.356  AZ=0   Z=5.4 ..
AW02098 E-W CONS EW1 X=211.672 Y=23.558
 W=8.399 H=5.4 AZ=76.922 S-S YES ..
I02187 I-W CONS IW1 X=205.485 Y=30.745
 W=4.4 H=5.4 AZ=166.922 N-T RM02050 ..
I02159 I-W CONS IW1 X=206.809 Y=25.046
 W=5.85 H=5.4 AZ=76.922 N-T RM02050 ..
I02255 I-W CONS IW1 X=205.834 Y=24.82
 W=1.001 H=5.4 AZ=166.922 N-T RM02050 ..
I02254 I-W CONS IW1 X=206.412 Y=22.336
 W=2.55 H=5.4 AZ=76.922 N-T RM02050 ..
D02056 I-W CONS DR1 X=206.392 Y=0
 A=4.515 N-T RM02050 ..
I02160 I-W CONS IW1 X=206.412 Y=22.336
 W=1 H=5.4 AZ=166.922 N-T RM02050 ..
B02012 I-W CONS COMMBOARD1 X=206.383 Y=27.456 Z=0
 A=11.025 AZ=159.88 TILT=180 N-T RM01048 ..
B02066 I-W CONS COMMBOARD1 X=206.454 Y=22.221 Z=0
 A=0.2 AZ=159.88 TILT=180 N-T RM01042 ..
B02073 I-W CONS COMMBOARD1 X=207.529 Y=22.171 Z=0
 A=34.457 AZ=159.88 TILT=180 N-T RM01048 ..
B02095 E-W CONS ABOARD1 X=210.74 Y=23.217 Z=0
 W=2.5 H=1 AZ=69.88 TILT=180 ..
B02096 E-W CONS ABOARD1 X=206.367 Y=22.531 Z=0
 W=2.35 H=1 AZ=69.88 TILT=180 ..

RM02047=SPACE S-C=CondType1
 A=75.78  V=409.212  AZ=0   Z=5.4 ..
AW02039 E-W CONS EW1 X=64.328 Y=9.296
 W=0.3 H=5.4 AZ=339.88 S-S YES ..
AW02040 E-W CONS EW1 X=64.046 Y=9.192
 W=0.7 H=5.4 AZ=69.88 S-S YES ..
AW02118 E-W CONS EW1 X=56.609 Y=3.912
 W=5.3 H=5.4 AZ=249.88 S-S YES ..
D02027 Door CONS DR1 X=0.4 Y=0.001
 W=2.199 H=2.099 ..
D02028 Door CONS DR1 X=2.6 Y=0.001
 W=2.199 H=2.099 ..
AW02070 E-W CONS EW1 X=66.695 Y=1.962
 W=1.5 H=5.4 AZ=69.88 S-S YES ..
AW02257 E-W CONS EW1 X=66.179 Y=3.371
 W=0.3 H=5.4 AZ=159.88 S-S YES ..
AW02256 E-W CONS EW1 X=66.461 Y=3.474
 W=6.2 H=5.4 AZ=69.881 S-S YES ..
WIN02119  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-4
 X=0.1 Y=0
 W=5.999 H=4.999 ..
I02116 I-W CONS IW1 X=63.806 Y=9.85
 W=8.8 H=5.4 AZ=339.88 N-T RM02048 ..
I02122 I-W CONS IW1 X=55.543 Y=6.823
 W=3.1 H=5.4 AZ=249.88 N-T RM02048 ..
B02006 I-W CONS COMMBOARD1 X=62.565 Y=4.922 Z=0
 A=11.316 AZ=159.88 TILT=180 N-T RM01014 ..
B02007 I-W CONS COMMBOARD1 X=63.975 Y=1.072 Z=0
 A=11.316 AZ=159.88 TILT=180 N-T RM01014 ..
B02026 I-W CONS COMMBOARD1 X=58.432 Y=-1.065 Z=0
 A=75.779 AZ=159.88 TILT=180 N-T RM01014 ..

RM02048=SPACE S-C=CondType2
 A=1399.42  V=7556.88  AZ=0   Z=5.4 ..
AW02268 E-W CONS EW1 X=61.987 Y=20.046
 W=10.2 H=5.4 AZ=339.88 S-S YES ..
AW02269 E-W CONS EW1 X=52.478 Y=16.35
 W=1.6 H=5.4 AZ=249.88 S-S YES ..
AW02270 E-W CONS EW1 X=53.029 Y=14.847
 W=0.7 H=5.4 AZ=339.88 S-S YES ..
AW02042 E-W CONS EW1 X=52.371 Y=14.607
 W=0.3 H=5.4 AZ=69.88 S-S YES ..
AW02287 E-W CONS EW2 X=52.268 Y=14.888
 W=1.4 H=5.4 AZ=339.88 S-S YES ..
WALL02287  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=1.399 H=4.483 ..
AW02064 E-W CONS EW1 X=50.954 Y=14.407
 W=0.3 H=5.4 AZ=249.88 S-S YES ..
AW02062 E-W CONS EW1 X=51.057 Y=14.125
 W=1 H=5.4 AZ=339.88 S-S YES ..
AW02065 E-W CONS EW1 X=50.118 Y=13.781
 W=0.3 H=5.4 AZ=69.88 S-S YES ..
AW02288 E-W CONS EW2 X=50.015 Y=14.063
 W=1.4 H=5.4 AZ=339.88 S-S YES ..
WALL02288  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=1.399 H=4.483 ..
AW02066 E-W CONS EW1 X=48.7 Y=13.581
 W=0.3 H=5.4 AZ=249.88 S-S YES ..
AW02063 E-W CONS EW1 X=48.803 Y=13.3
 W=1 H=5.4 AZ=339.88 S-S YES ..
AW02067 E-W CONS EW1 X=47.864 Y=12.956
 W=0.3 H=5.4 AZ=69.88 S-S YES ..
AW02289 E-W CONS EW2 X=47.761 Y=13.237
 W=1.4 H=5.4 AZ=339.88 S-S YES ..
WALL02289  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=1.399 H=4.483 ..
AW02068 E-W CONS EW1 X=46.447 Y=12.756
 W=0.3 H=5.4 AZ=249.88 S-S YES ..
AW02043 E-W CONS EW1 X=46.55 Y=12.474
 W=5.3 H=5.4 AZ=339.882 S-S YES ..
WIN02117  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0.7 Y=0
 W=2.299 H=4.299 ..
AW02230 E-W CONS EW1 X=41.573 Y=10.651
 W=4.2 H=5.4 AZ=69.88 S-S YES ..
WIN02045  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-4
 X=1.3 Y=0
 W=2.399 H=4.299 ..
AW02252 E-W CONS EW1 X=40.128 Y=14.595
 W=29.8 H=5.4 AZ=339.88 S-S YES ..
WIN02049  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0.1 Y=0
 W=3.699 H=4.299 ..
WIN02050  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=20.7 Y=0
 W=3.999 H=4.299 ..
WIN02051  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=17.5 Y=0
 W=1.999 H=4.299 ..
WIN02052  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=25.3 Y=0
 W=4.299 H=4.299 ..
WIN02053  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=4.2 Y=0
 W=3.699 H=4.299 ..
WIN02054  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=12.6 Y=0
 W=3.699 H=4.299 ..
WIN02055  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=8.5 Y=0
 W=3.699 H=4.299 ..
AW02253 E-W CONS EW1 X=12.147 Y=4.344
 W=1.8 H=5.4 AZ=249.88 S-S YES ..
AW02233 E-W CONS EW1 X=12.766 Y=2.654
 W=1.1 H=5.4 AZ=339.88 S-S YES ..
AW02276 E-W CONS EW2 X=11.733 Y=2.275
 W=5.758 H=5.4 AZ=339.88 S-S YES ..
WALL02276  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=5.757 H=4.481 ..
AW02275 E-W CONS EW2 X=6.327 Y=0.294
 W=5.858 H=5.4 AZ=294.88 S-S YES ..
WALL02275  WINDOW G-T EWIN5 SHADING-SCHEDULE = SC-SASV-15
 X=0 Y=0
 W=5.857 H=4.481 ..
AW02274 E-W CONS EW2 X=3.862 Y=-5.02
 W=10.358 H=5.4 AZ=249.88 S-S YES ..
WALL02274  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=10.357 H=4.48 ..
AW02231 E-W CONS EW1 X=7.425 Y=-14.745
 W=0.5 H=5.4 AZ=249.88 S-S YES ..
AW02232 E-W CONS EW1 X=7.597 Y=-15.215
 W=2.2 H=5.4 AZ=159.88 S-S YES ..
AW02227 E-W CONS EW1 X=9.663 Y=-14.458
 W=34 H=5.4 AZ=249.88 S-S YES ..
WIN02057  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-16
 X=0.5 Y=0
 W=3.899 H=4.299 ..
WIN02058  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-16
 X=4.6 Y=0
 W=3.699 H=4.299 ..
WIN02059  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-16
 X=17.3 Y=0
 W=3.799 H=4.299 ..
WIN02060  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-16
 X=29.7 Y=0
 W=3.799 H=4.299 ..
WIN02061  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-16
 X=21.3 Y=0
 W=3.799 H=4.299 ..
WIN02065  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-16
 X=12.9 Y=0
 W=3.799 H=4.299 ..
WIN02066  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-16
 X=8.9 Y=0
 W=3.799 H=4.299 ..
WIN02067  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-16
 X=25.7 Y=0
 W=3.799 H=4.299 ..
AW02226 E-W CONS EW1 X=21.359 Y=-46.383
 W=17.2 H=5.4 AZ=159.88 S-S YES ..
WIN02062  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-17
 X=4.5 Y=0
 W=3.799 H=4.299 ..
WIN02063  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-17
 X=0.5 Y=0
 W=3.799 H=4.299 ..
WIN02064  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-17
 X=8.9 Y=0
 W=3.799 H=4.299 ..
WIN02071  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-17
 X=12.9 Y=0
 W=3.799 H=4.299 ..
AW02222 E-W CONS EW1 X=37.509 Y=-40.467
 W=17 H=5.4 AZ=69.88 S-S YES ..
WIN02068  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-18
 X=0.5 Y=0
 W=3.799 H=4.299 ..
WIN02069  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-18
 X=8.9 Y=0
 W=3.799 H=4.299 ..
WIN02070  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-18
 X=12.9 Y=0
 W=3.799 H=4.299 ..
WIN02072  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-18
 X=4.5 Y=0
 W=3.799 H=4.299 ..
AW02223 E-W CONS EW1 X=27.155 Y=-12.204
 W=3.5 H=5.4 AZ=69.88 S-S YES ..
AW02117 E-W CONS EW1 X=25.951 Y=-8.917
 W=30.45 H=5.4 AZ=159.88 S-S YES ..
WIN02026  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-19
 X=0.1 Y=0
 W=1.049 H=4.299 ..
WIN02073  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-19
 X=1.35 Y=0
 W=3.799 H=4.299 ..
WIN02074  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-19
 X=22.55 Y=0
 W=3.799 H=4.299 ..
WIN02075  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-19
 X=26.55 Y=0
 W=3.799 H=4.299 ..
WIN02076  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-19
 X=9.75 Y=0
 W=3.799 H=4.299 ..
WIN02077  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-19
 X=14.15 Y=0
 W=3.799 H=4.299 ..
WIN02078  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-19
 X=5.75 Y=0
 W=3.799 H=4.299 ..
WIN02079  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-19
 X=18.15 Y=0
 W=3.799 H=4.299 ..
AW02119 E-W CONS EW1 X=54.543 Y=1.557
 W=1.5 H=5.4 AZ=69.88 S-S YES ..
AW02120 E-W CONS EW1 X=54.027 Y=2.966
 W=2.75 H=5.4 AZ=159.88 S-S YES ..
AW02041 E-W CONS EW1 X=63.806 Y=9.85
 W=1.8 H=5.4 AZ=159.88 S-S YES ..
AW02286 E-W CONS EW1 X=65.496 Y=10.469
 W=10.2 H=5.4 AZ=69.88 S-S YES ..
WIN02118  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-20
 X=0.1 Y=0
 W=9.999 H=4.299 ..
I02285 I-W CONS IW1 X=52.478 Y=16.35
 W=0.2 H=5.4 AZ=69.88 N-T RM02051 ..
R02002 ROOF CONS RF1 X=19.293 Y=-47.14 Z=5.4
 W=38.2 H=18.59 AZ=159.88 TILT=0 ..
R02003 ROOF CONS RF1 X=55.918 Y=6.96 Z=5.4
 W=10.2 H=2.779 AZ=159.88 TILT=0 ..
B02015 I-W CONS COMMBOARD1 X=21.359 Y=-46.383 Z=0
 A=292.399 AZ=159.88 TILT=180 N-T RM01003 ..
B02080 I-W CONS COMMBOARD1 X=12 Y=-27.234 Z=0
 A=1059.18 AZ=159.88 TILT=180 N-T RM01053 ..
B02098 E-W CONS ABOARD1 X=57.159 Y=11.568 Z=0
 W=7.45 H=0.542 AZ=69.88 TILT=180 ..
B02099 E-W CONS ABOARD1 X=15.511 Y=-30.421 Z=0
 W=8.4 H=5.065 AZ=69.88 TILT=180 ..
B02100 E-W CONS ABOARD1 X=46.55 Y=12.474 Z=0
 W=1.4 H=0.3 AZ=69.88 TILT=180 ..
B02101 E-W CONS ABOARD1 X=48.803 Y=13.3 Z=0
 W=1.4 H=0.3 AZ=69.88 TILT=180 ..
B02102 E-W CONS ABOARD1 X=51.057 Y=14.125 Z=0
 W=1.4 H=0.3 AZ=69.88 TILT=180 ..

RM02049=SPACE S-C=CondType4
 A=1858.5  V=10035.9  AZ=0   Z=5.4 ..
AW02220 E-W CONS EW1 X=128.349 Y=29.022
 W=10.9 H=5.4 AZ=339.88 S-S YES ..
WIN02043  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=2.6 Y=0
 W=7.099 H=4.299 ..
AW02061 E-W CONS EW1 X=118.114 Y=25.272
 W=3.851 H=5.4 AZ=249.88 S-S YES ..
AW02265 E-W CONS EW1 X=119.439 Y=21.656
 W=4.949 H=5.4 AZ=249.88 S-S YES ..
WIN02115  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-11
 X=0 Y=0
 W=4.848 H=4.299 ..
AW02259 E-W CONS EW1 X=121.142 Y=17.009
 W=5.9 H=5.4 AZ=339.88 S-S YES ..
WIN02114  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0.1 Y=0
 W=5.699 H=4.299 ..
AW02162 E-W CONS EW1 X=115.602 Y=14.98
 W=8.8 H=5.4 AZ=69.88 S-S YES ..
WIN02033  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-21
 X=0.5 Y=0
 W=6.849 H=4.299 ..
AW02175 E-W CONS EW1 X=112.575 Y=23.243
 W=6.9 H=5.4 AZ=339.88 S-S YES ..
AW02174 E-W CONS EW1 X=106.096 Y=20.869
 W=0.3 H=5.4 AZ=69.88 S-S YES ..
AW02281 E-W CONS EW2 X=105.992 Y=21.151
 W=1.4 H=5.4 AZ=339.88 S-S YES ..
WALL02281  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=1.399 H=4.483 ..
AW02173 E-W CONS EW1 X=104.678 Y=20.669
 W=0.3 H=5.4 AZ=249.88 S-S YES ..
AW02172 E-W CONS EW1 X=104.781 Y=20.388
 W=1 H=5.4 AZ=339.88 S-S YES ..
AW02171 E-W CONS EW1 X=103.842 Y=20.044
 W=0.3 H=5.4 AZ=69.88 S-S YES ..
AW02280 E-W CONS EW2 X=103.739 Y=20.325
 W=1.4 H=5.4 AZ=339.88 S-S YES ..
WALL02280  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=1.399 H=4.483 ..
AW02170 E-W CONS EW1 X=102.424 Y=19.844
 W=0.3 H=5.4 AZ=249.88 S-S YES ..
AW02168 E-W CONS EW1 X=102.528 Y=19.562
 W=1 H=5.4 AZ=339.88 S-S YES ..
AW02169 E-W CONS EW1 X=101.589 Y=19.218
 W=0.3 H=5.4 AZ=69.88 S-S YES ..
AW02279 E-W CONS EW2 X=101.485 Y=19.5
 W=1.4 H=5.4 AZ=339.88 S-S YES ..
WALL02279  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=1.399 H=4.483 ..
AW02167 E-W CONS EW1 X=100.171 Y=19.018
 W=0.3 H=5.4 AZ=249.88 S-S YES ..
AW02165 E-W CONS EW1 X=100.274 Y=18.737
 W=1 H=5.4 AZ=339.88 S-S YES ..
AW02166 E-W CONS EW1 X=99.335 Y=18.393
 W=0.3 H=5.4 AZ=69.88 S-S YES ..
AW02277 E-W CONS EW2 X=99.232 Y=18.674
 W=20.2 H=5.4 AZ=339.88 S-S YES ..
WALL02277  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=20.199 H=4.48 ..
AW02278 E-W CONS EW2 X=80.265 Y=11.726
 W=8.65 H=5.4 AZ=249.88 S-S YES ..
WALL02278  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-22
 X=0 Y=0
 W=8.649 H=4.481 ..
AW02177 E-W CONS EW1 X=86.566 Y=-4.603
 W=0.3 H=5.4 AZ=339.88 S-S YES ..
AW02047 E-W CONS EW1 X=86.284 Y=-4.706
 W=8 H=5.4 AZ=249.88 S-S YES ..
WIN02124  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-5
 X=0.2 Y=0
 W=7.199 H=5.399 ..
AW02178 E-W CONS EW1 X=89.036 Y=-12.218
 W=0.3 H=5.4 AZ=159.88 S-S YES ..
AW02096 E-W CONS EW1 X=92.345 Y=-20.378
 W=8.4 H=5.4 AZ=249.88 S-S YES ..
WIN02022  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-23
 X=4.5 Y=0.9
 W=3.399 H=3.849 ..
AW02273 E-W CONS EW1 X=95.234 Y=-28.265
 W=50.8 H=5.4 AZ=159.88 S-S YES ..
WIN02080  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-24
 X=38.1 Y=0
 W=3.799 H=4.299 ..
WIN02081  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-24
 X=25.7 Y=0
 W=3.799 H=4.299 ..
WIN02082  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-24
 X=42.5 Y=0
 W=3.799 H=4.299 ..
WIN02083  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-24
 X=34.1 Y=0
 W=3.799 H=4.299 ..
WIN02084  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-24
 X=12.9 Y=0
 W=3.499 H=4.299 ..
WIN02085  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-24
 X=4.5 Y=0
 W=3.799 H=4.299 ..
WIN02086  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-24
 X=8.9 Y=0
 W=3.799 H=4.299 ..
WIN02087  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-24
 X=46.5 Y=0
 W=3.799 H=4.299 ..
WIN02088  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-24
 X=0.5 Y=0
 W=3.799 H=4.299 ..
WIN02090  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-24
 X=29.7 Y=0
 W=3.799 H=4.299 ..
WIN02091  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-24
 X=17.6 Y=0
 W=3.499 H=4.299 ..
AW02216 E-W CONS EW1 X=142.934 Y=-10.791
 W=8.4 H=5.4 AZ=69.88 S-S YES ..
WIN02104  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-25
 X=0.8 Y=0
 W=3.499 H=4.299 ..
WIN02105  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-25
 X=4.5 Y=0
 W=3.499 H=4.299 ..
AW02260 E-W CONS EW1 X=137.018 Y=5.36
 W=8 H=5.4 AZ=69.88 S-S YES ..
WIN02123  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-25
 X=0.1 Y=0
 W=7.799 H=4.299 ..
AW02189 E-W CONS EW1 X=131.239 Y=21.134
 W=8.4 H=5.4 AZ=69.88 S-S YES ..
WIN02034  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-21
 X=1 Y=0
 W=4.749 H=4.299 ..
I02026 I-W CONS IW1 X=93.281 Y=2.649
 W=1.8 H=5.4 AZ=249.88 N-T RM02049 ..
R02004 ROOF CONS RF1 X=95.234 Y=-28.265 Z=5.4
 W=50.8 H=8.984 AZ=159.88 TILT=0 ..
B02040 I-W CONS COMMBOARD1 X=95.234 Y=-28.265 Z=0
 A=632.726 AZ=159.88 TILT=180 N-T RM01025 ..
B02047 I-W CONS COMMBOARD1 X=86.566 Y=-4.603 Z=0
 A=728.824 AZ=159.88 TILT=180 N-T RM01031 ..
B02084 E-W CONS ABOARD1 X=136.362 Y=-13.199 Z=0
 W=8.4 H=5.824 AZ=69.88 TILT=180 ..
B02085 E-W CONS ABOARD1 X=93.79 Y=-24.322 Z=0
 W=7 H=4.2 AZ=69.88 TILT=180 ..
B02086 E-W CONS ABOARD1 X=83.24 Y=3.604 Z=0
 W=20.2 H=0.424 AZ=69.88 TILT=180 ..
B02087 E-W CONS ABOARD1 X=104.781 Y=20.388 Z=0
 W=1.4 H=0.3 AZ=69.88 TILT=180 ..
B02088 E-W CONS ABOARD1 X=102.528 Y=19.562 Z=0
 W=1.4 H=0.3 AZ=69.88 TILT=180 ..
B02089 E-W CONS ABOARD1 X=100.274 Y=18.737 Z=0
 W=1.4 H=0.3 AZ=69.88 TILT=180 ..
B02090 E-W CONS ABOARD1 X=89.036 Y=-12.218 Z=0
 W=40.35 H=10.131 AZ=69.88 TILT=180 ..

RM02050=SPACE S-C=CondType4
 A=2397.63  V=12947.2  AZ=0   Z=5.4 ..
AW02195 E-W CONS EW1 X=205.924 Y=48.299
 W=5.6 H=5.4 AZ=346.922 S-S YES ..
AW02163 E-W CONS EW1 X=197.352 Y=46.308
 W=0.6 H=5.4 AZ=346.922 S-S YES ..
AW02045 E-W CONS EW1 X=196.768 Y=46.173
 W=0.299 H=5.4 AZ=76.922 S-S YES ..
AW02264 E-W CONS EW1 X=196.701 Y=46.464
 W=19.201 H=5.4 AZ=346.922 S-S YES ..
WIN02127  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0.101 Y=0
 W=18.999 H=5.399 ..
AW02263 E-W CONS EW1 X=177.998 Y=42.12
 W=3.499 H=5.4 AZ=256.922 S-S YES ..
WIN02128  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-26
 X=0.2 Y=0
 W=3.199 H=5.399 ..
AW02048 E-W CONS EW1 X=178.79 Y=38.711
 W=0.199 H=5.4 AZ=346.922 S-S YES ..
AW02261 E-W CONS EW1 X=178.595 Y=38.665
 W=4.8 H=5.4 AZ=346.922 S-S YES ..
WIN02126  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0.093 Y=0
 W=4.699 H=4.299 ..
AW02183 E-W CONS EW1 X=173.919 Y=37.58
 W=3.199 H=5.4 AZ=76.922 S-S YES ..
AW02203 E-W CONS EW1 X=173.195 Y=40.696
 W=25.6 H=5.4 AZ=346.922 S-S YES ..
WIN02036  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=8.9 Y=0
 W=2.299 H=4.399 ..
WIN02037  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0.5 Y=0
 W=7.099 H=4.399 ..
WIN02038  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=13.7 Y=0
 W=2.299 H=4.399 ..
AW02205 E-W CONS EW1 X=148.259 Y=34.904
 W=7.3 H=5.4 AZ=256.922 S-S YES ..
WIN02039  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-24
 X=1.45 Y=0
 W=5.749 H=4.299 ..
AW02283 E-W CONS EW1 X=152.152 Y=18.15
 W=8 H=5.4 AZ=256.923 S-S YES ..
WIN02125  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-27
 X=0.087 Y=0
 W=7.799 H=4.299 ..
AW02111 E-W CONS EW1 X=155.953 Y=1.785
 W=8.399 H=5.4 AZ=256.922 S-S YES ..
WIN02112  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-27
 X=4.1 Y=0
 W=3.799 H=4.299 ..
WIN02113  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-27
 X=0.1 Y=0
 W=3.799 H=4.299 ..
AW02204 E-W CONS EW1 X=157.853 Y=-6.397
 W=25.2 H=5.4 AZ=166.922 S-S YES ..
WIN02106  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-28
 X=0.1 Y=0
 W=3.799 H=4.299 ..
WIN02107  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-28
 X=16.9 Y=0
 W=3.799 H=4.299 ..
WIN02108  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-28
 X=4.1 Y=0
 W=3.499 H=4.299 ..
WIN02109  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-28
 X=8.8 Y=0
 W=3.499 H=4.299 ..
WIN02110  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-28
 X=12.5 Y=0
 W=3.799 H=4.299 ..
WIN02111  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-28
 X=20.9 Y=0
 W=3.799 H=4.299 ..
AW02185 E-W CONS EW1 X=182.4 Y=-0.695
 W=4 H=5.4 AZ=256.922 S-S YES ..
WIN02116  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-1
 X=0.1 Y=0
 W=3.199 H=4.299 ..
AW02184 E-W CONS EW1 X=183.306 Y=-4.591
 W=33.999 H=5.4 AZ=166.922 S-S YES ..
AW02107 E-W CONS EW1 X=216.423 Y=3.102
 W=4 H=5.4 AZ=76.922 S-S YES ..
AW02194 E-W CONS EW1 X=209.771 Y=31.74
 W=17 H=5.4 AZ=76.922 S-S YES ..
I02044 I-W CONS IW1 X=178.79 Y=38.711
 W=0.201 H=5.4 AZ=166.922 N-T RM02050 ..
R02006 ROOF CONS RF1 X=161.716 Y=-16.939 Z=5.4
 W=33.999 H=17.47 AZ=159.88 TILT=0 ..
B02058 I-W CONS COMMBOARD1 X=155.348 Y=12.951 Z=0
 A=817.917 AZ=159.88 TILT=180 N-T RM01039 ..
B02063 I-W CONS COMMBOARD1 X=197.656 Y=22.388 Z=0
 A=15.949 AZ=159.88 TILT=180 N-T RM01040 ..
B02064 I-W CONS COMMBOARD1 X=196.999 Y=25.212 Z=0
 A=15.399 AZ=159.88 TILT=180 N-T RM01041 ..
B02067 I-W CONS COMMBOARD1 X=164.731 Y=-11.032 Z=0
 A=814.48 AZ=159.88 TILT=180 N-T RM01042 ..
B02068 I-W CONS COMMBOARD1 X=203.754 Y=29.054 Z=0
 A=2.099 AZ=159.88 TILT=180 N-T RM01043 ..
B02074 I-W CONS COMMBOARD1 X=206.826 Y=36.58 Z=0
 A=2.28 AZ=159.88 TILT=180 N-T RM01049 ..
B02075 I-W CONS COMMBOARD1 X=200.227 Y=34.398 Z=0
 A=86.035 AZ=159.88 TILT=180 N-T RM01050 ..
B02076 I-W CONS COMMBOARD1 X=202.865 Y=24.034 Z=0
 A=5.8 AZ=159.88 TILT=180 N-T RM01051 ..
B02091 E-W CONS ABOARD1 X=178.066 Y=41.828 Z=0
 W=19.201 H=0.299 AZ=69.88 TILT=180 ..
B02092 E-W CONS ABOARD1 X=158.06 Y=-6.961 Z=0
 W=8.399 H=5.7 AZ=69.88 TILT=180 ..
B02093 E-W CONS ABOARD1 X=184.739 Y=-8.505 Z=0
 W=33.999 H=4 AZ=69.88 TILT=180 ..
B02097 E-W CONS ABOARD1 X=156.231 Y=4.164 Z=0
 W=45 H=9.956 AZ=69.88 TILT=180 ..

RM02051=SPACE S-C=CondType1
 A=0.15  V=0.81  AZ=0   Z=5.4 ..
AW02284 E-W CONS EW1 X=52.409 Y=16.538
 W=0.75 H=5.4 AZ=339.88 S-S YES ..
AW02282 E-W CONS EW1 X=51.705 Y=16.28
 W=0.2 H=5.4 AZ=249.88 S-S YES ..
AW02271 E-W CONS EW1 X=51.774 Y=16.092
 W=0.75 H=5.4 AZ=159.88 S-S YES ..
R02007 ROOF CONS RF1 X=51.774 Y=16.092 Z=5.4
 W=0.75 H=0.2 AZ=159.88 TILT=0 ..
B02081 E-W CONS ABOARD1 X=51.774 Y=16.092 Z=0
 W=0.75 H=0.2 AZ=69.88 TILT=180 ..

RM02052=SPACE S-C=CondType2
 A=482.68  V=2606.47  AZ=0   Z=5.4 ..
AW02242 E-W CONS EW1 X=71.029 Y=-9.869
 W=34 H=5.4 AZ=339.88 S-S YES ..
WIN02093  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=4.5 Y=0
 W=3.799 H=4.299 ..
WIN02094  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=8.9 Y=0
 W=3.799 H=4.299 ..
WIN02095  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0.5 Y=0
 W=3.799 H=4.299 ..
WIN02096  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=12.9 Y=0
 W=3.799 H=4.299 ..
WIN02100  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=29.7 Y=0
 W=3.649 H=4.299 ..
WIN02101  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=21.3 Y=0
 W=3.799 H=4.299 ..
WIN02102  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=25.7 Y=0
 W=3.799 H=4.299 ..
WIN02103  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=17.3 Y=0
 W=3.799 H=4.299 ..
AW02251 E-W CONS EW1 X=37.692 Y=-24.105
 W=15.3 H=5.4 AZ=249.88 S-S YES ..
WIN02048  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-29
 X=0.1 Y=0
 W=2.299 H=4.399 ..
WIN02089  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-29
 X=7 Y=0
 W=3.799 H=4.299 ..
WIN02092  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-29
 X=2.6 Y=0
 W=3.799 H=4.299 ..
WIN02097  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-29
 X=11 Y=0
 W=4.199 H=4.299 ..
AW02250 E-W CONS EW1 X=42.955 Y=-38.472
 W=10.3 H=5.4 AZ=159.88 S-S YES ..
WIN02047  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-30
 X=8.2 Y=0.9
 W=1.999 H=3.849 ..
WIN02098  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-17
 X=0.1 Y=0
 W=3.649 H=4.299 ..
WIN02099  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-17
 X=3.95 Y=0
 W=3.649 H=4.299 ..
AW02291 E-W CONS EW2 X=52.626 Y=-34.928
 W=0.3 H=5.4 AZ=249.88 S-S YES ..
WALL02291  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=0.299 H=4.495 ..
AW02290 E-W CONS EW2 X=52.73 Y=-35.21
 W=9.4 H=5.4 AZ=159.88 S-S YES ..
WALL02290  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-31
 X=0 Y=0
 W=9.399 H=4.48 ..
AW02292 E-W CONS EW2 X=61.556 Y=-31.977
 W=8.4 H=5.4 AZ=69.88 S-S YES ..
WALL02292  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-4
 X=0 Y=0
 W=8.399 H=4.481 ..
AW02001 E-W CONS EW1 X=58.666 Y=-24.089
 W=0.3 H=5.4 AZ=69.88 S-S YES ..
AW02069 E-W CONS EW1 X=58.563 Y=-23.808
 W=16.5 H=5.4 AZ=159.88 S-S YES ..
WIN02016  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-5
 X=10.45 Y=0
 W=5.949 H=4.299 ..
WIN02017  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-5
 X=2.05 Y=0.9
 W=4.699 H=4.299 ..
AW02229 E-W CONS EW1 X=74.056 Y=-18.132
 W=8.8 H=5.4 AZ=69.88 S-S YES ..
WIN02122  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-4
 X=2.55 Y=0
 W=4.799 H=4.299 ..
R02008 ROOF CONS RF1 X=42.955 Y=-38.472 Z=5.4
 W=10.3 H=8.4 AZ=159.88 TILT=0 ..
B02078 I-W CONS COMMBOARD1 X=43.058 Y=-38.753 Z=0
 A=482.677 AZ=159.88 TILT=180 N-T RM01052 ..

RM03001=SPACE S-C=CondType1
 A=6.345  V=34.263  AZ=0   Z=10.8 ..
AW03302 E-W CONS EW1 X=18.892 Y=-15.23
 W=4.7 H=5.4 AZ=249.88 S-S YES ..
I03183 I-W CONS IW1 X=18.892 Y=-15.23
 W=1.35 H=5.4 AZ=159.88 N-T RM03010 ..
I03184 I-W CONS IW1 X=20.509 Y=-19.644
 W=1.35 H=5.4 AZ=159.88 N-T RM03006 ..
I03185 I-W CONS IW1 X=21.776 Y=-19.179
 W=4.7 H=5.4 AZ=69.88 N-T RM03002 ..
R03001 ROOF CONS RF1 X=20.509 Y=-19.644 Z=5.4
 W=4.7 H=1.35 AZ=159.88 TILT=0 ..
B03068 I-W CONS COMMBOARD1 X=20.509 Y=-19.644 Z=0
 A=6.345 AZ=159.88 TILT=180 N-T RM02048 ..

RM03002=SPACE S-C=CondType1
 A=6.345  V=34.263  AZ=0   Z=10.8 ..
I03181 I-W CONS IW1 X=20.159 Y=-14.766
 W=1.35 H=5.4 AZ=159.88 N-T RM03010 ..
I03182 I-W CONS IW1 X=21.776 Y=-19.179
 W=1.35 H=5.4 AZ=159.88 N-T RM03006 ..
I03305 I-W CONS IW1 X=23.044 Y=-18.715
 W=4.7 H=5.4 AZ=69.88 N-T RM03003 ..
R03002 ROOF CONS RF1 X=21.776 Y=-19.179 Z=5.4
 W=4.7 H=1.35 AZ=159.88 TILT=0 ..
B03013 I-W CONS COMMBOARD1 X=21.776 Y=-19.179 Z=0
 A=6.345 AZ=159.88 TILT=180 N-T RM02001 ..

RM03003=SPACE S-C=CondType1
 A=8.03  V=43.362  AZ=0   Z=10.8 ..
I03154 I-W CONS IW1 X=21.427 Y=-14.302
 W=1.9 H=5.4 AZ=159.88 N-T RM03010 ..
I03321 I-W CONS IW1 X=23.044 Y=-18.715
 W=1.6 H=5.4 AZ=159.88 N-T RM03006 ..
I03156 I-W CONS IW1 X=24.546 Y=-18.164
 W=3 H=5.4 AZ=69.88 N-T RM03004 ..
I03150 I-W CONS IW1 X=23.514 Y=-15.348
 W=0.3 H=5.4 AZ=159.88 N-T RM03004 ..
I03149 I-W CONS IW1 X=23.796 Y=-15.244
 W=1.7 H=5.4 AZ=69.88 N-T RM03008 ..
D03037 I-W CONS DR1 X=26.993 Y=0
 A=1.68 N-T RM03008 ..
R03003 ROOF CONS RF1 X=23.044 Y=-18.715 Z=5.4
 W=4.7 H=1.709 AZ=159.88 TILT=0 ..
B03014 I-W CONS COMMBOARD1 X=23.044 Y=-18.715 Z=0
 A=8.03 AZ=159.88 TILT=180 N-T RM02002 ..

RM03004=SPACE S-C=CondType1
 A=4.5  V=24.3  AZ=0   Z=10.8 ..
I03148 I-W CONS IW1 X=23.796 Y=-15.244
 W=1.2 H=5.4 AZ=159.88 N-T RM03008 ..
D03036 I-W CONS DR1 X=28.228 Y=0
 A=1.68 N-T RM03008 ..
I03155 I-W CONS IW1 X=24.546 Y=-18.164
 W=1.5 H=5.4 AZ=159.88 N-T RM03006 ..
I03323 I-W CONS IW1 X=25.955 Y=-17.648
 W=3 H=5.4 AZ=69.88 N-T RM03007 ..
R03004 ROOF CONS RF1 X=24.546 Y=-18.164 Z=5.4
 W=3 H=1.5 AZ=159.88 TILT=0 ..
B03015 I-W CONS COMMBOARD1 X=24.546 Y=-18.164 Z=0
 A=4.5 AZ=159.88 TILT=180 N-T RM02003 ..

RM03005=SPACE S-C=CondType2
 A=75.68  V=408.672  AZ=0   Z=10.8 ..
AW03301 E-W CONS EW1 X=23.398 Y=-27.531
 W=8.6 H=5.4 AZ=249.88 S-S YES ..
WIN03087  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-32
 X=0.6 Y=0
 W=7.149 H=4.299 ..
AW03300 E-W CONS EW1 X=26.356 Y=-35.606
 W=8.8 H=5.4 AZ=159.88 S-S YES ..
WIN03086  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-32
 X=0.8 Y=0.9
 W=7.199 H=4.299 ..
AW03303 E-W CONS EW1 X=34.619 Y=-32.579
 W=8.6 H=5.4 AZ=69.88 S-S YES ..
WIN03100  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-9
 X=4.5 Y=0
 W=3.799 H=4.299 ..
WIN03105  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-9
 X=0.5 Y=0
 W=3.799 H=4.299 ..
I03325 I-W CONS IW1 X=23.398 Y=-27.531
 W=8.8 H=5.4 AZ=159.88 N-T RM03006 ..
R03005 ROOF CONS RF1 X=26.356 Y=-35.606 Z=5.4
 W=8.8 H=8.6 AZ=159.88 TILT=0 ..
B03069 I-W CONS COMMBOARD1 X=26.356 Y=-35.606 Z=0
 A=75.678 AZ=159.88 TILT=180 N-T RM02048 ..

RM03006=SPACE S-C=CondType1
 A=73.92  V=399.168  AZ=0   Z=10.8 ..
AW03142 E-W CONS EW1 X=20.509 Y=-19.644
 W=8.4 H=5.4 AZ=249.88 S-S YES ..
WIN03032  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-32
 X=1.8 Y=0
 W=4.749 H=4.299 ..
AW03141 E-W CONS EW1 X=31.661 Y=-24.504
 W=8.4 H=5.4 AZ=69.88 S-S YES ..
D03030 Door CONS DR1 X=2 Y=0.001
 W=2.199 H=2.099 ..
D03031 Door CONS DR1 X=4.2 Y=0.001
 W=2.199 H=2.099 ..
I03322 I-W CONS IW1 X=25.955 Y=-17.648
 W=3 H=5.4 AZ=159.88 N-T RM03007 ..
R03006 ROOF CONS RF1 X=23.398 Y=-27.531 Z=5.4
 W=8.8 H=8.4 AZ=159.88 TILT=0 ..
B03007 I-W CONS COMMBOARD1 X=22.048 Y=-23.553 Z=0
 A=13.017 AZ=159.88 TILT=180 N-T RM02004 ..
B03008 I-W CONS COMMBOARD1 X=23.458 Y=-27.403 Z=0
 A=13.017 AZ=159.88 TILT=180 N-T RM02004 ..
B03016 I-W CONS COMMBOARD1 X=23.398 Y=-27.531 Z=0
 A=73.918 AZ=159.88 TILT=180 N-T RM02004 ..

RM03007=SPACE S-C=CondType1
 A=9  V=48.6  AZ=0   Z=10.8 ..
AW03324 E-W CONS EW1 X=28.772 Y=-16.617
 W=3 H=5.4 AZ=69.88 S-S YES ..
WIN03091  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-4
 X=0.95 Y=0
 W=1.099 H=3.849 ..
I03320 I-W CONS IW1 X=24.923 Y=-14.832
 W=3 H=5.4 AZ=159.88 N-T RM03008 ..
R03007 ROOF CONS RF1 X=25.955 Y=-17.648 Z=5.4
 W=3 H=3 AZ=159.88 TILT=0 ..
B03017 I-W CONS COMMBOARD1 X=25.955 Y=-17.648 Z=0
 A=8.999 AZ=159.88 TILT=180 N-T RM02005 ..

RM03008=SPACE S-C=CondType1
 A=7.14  V=38.556  AZ=0   Z=10.8 ..
AW03306 E-W CONS EW1 X=27.74 Y=-13.8
 W=1.7 H=5.4 AZ=69.88 S-S YES ..
D03088 Door CONS DR1 X=0.5 Y=0.001
 W=0.999 H=2.099 ..
I03147 I-W CONS IW1 X=23.211 Y=-13.648
 W=4.2 H=5.4 AZ=159.88 N-T RM03010 ..
R03008 ROOF CONS RF1 X=23.796 Y=-15.244 Z=5.4
 W=4.2 H=1.7 AZ=159.88 TILT=0 ..
B03018 I-W CONS COMMBOARD1 X=23.796 Y=-15.244 Z=0
 A=7.139 AZ=159.88 TILT=180 N-T RM02006 ..

RM03009=SPACE S-C=CondType1
 A=4.18  V=22.572  AZ=0   Z=10.8 ..
AW03192 E-W CONS EW1 X=39.104 Y=-21.564
 W=2.2 H=5.4 AZ=339.88 S-S YES ..
AW03190 E-W CONS EW1 X=37.038 Y=-22.321
 W=1.9 H=5.4 AZ=249.88 S-S YES ..
I03193 I-W CONS IW1 X=39.758 Y=-23.348
 W=2.2 H=5.4 AZ=339.88 N-T RM03015 ..
I03194 I-W CONS IW1 X=39.104 Y=-21.564
 W=1.9 H=5.4 AZ=249.88 N-T RM03015 ..
R03009 ROOF CONS RF1 X=37.692 Y=-24.105 Z=5.4
 W=2.2 H=1.9 AZ=159.88 TILT=0 ..
B03019 I-W CONS COMMBOARD1 X=37.692 Y=-24.105 Z=0
 A=4.179 AZ=159.88 TILT=180 N-T RM02007 ..

RM03010=SPACE S-C=CondType2
 A=393.5  V=2124.9  AZ=0   Z=10.8 ..
AW03296 E-W CONS EW2 X=39.413 Y=9.86
 W=1.85 H=5.4 AZ=339.88 S-S YES ..
WALL03296  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=1.849 H=4.482 ..
AW03105 E-W CONS EW1 X=37.676 Y=9.224
 W=26.05 H=5.4 AZ=339.88 S-S YES ..
WIN03019  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=9.2 Y=0.9
 W=7.199 H=4.299 ..
WIN03113  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=17.6 Y=0.9
 W=7.199 H=4.299 ..
AW03186 E-W CONS EW1 X=13.216 Y=0.263
 W=16.5 H=5.4 AZ=249.88 S-S YES ..
WIN03040  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-32
 X=5 Y=0
 W=7.199 H=4.299 ..
AW03304 E-W CONS EW1 X=27.155 Y=-12.203
 W=3.5 H=5.4 AZ=69.88 S-S YES ..
AW03297 E-W CONS EW1 X=25.951 Y=-8.917
 W=19.1 H=5.4 AZ=159.88 S-S YES ..
WIN03101  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-30
 X=6.8 Y=0
 W=3.799 H=4.299 ..
WIN03102  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-30
 X=15.2 Y=0
 W=3.799 H=4.299 ..
WIN03103  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-30
 X=2.8 Y=0
 W=3.799 H=4.299 ..
WIN03104  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-30
 X=11.2 Y=0
 W=3.799 H=4.299 ..
AW03160 E-W CONS EW1 X=43.885 Y=-2.347
 W=5.6 H=5.4 AZ=69.88 S-S YES ..
AW03104 E-W CONS EW2 X=41.959 Y=2.911
 W=7.4 H=5.4 AZ=69.88 S-S YES ..
WALL03104  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-33
 X=0 Y=0
 W=7.399 H=4.481 ..
R03010 ROOF CONS RF1 X=18.892 Y=-15.23 Z=5.4
 W=27.9 H=14.104 AZ=159.88 TILT=0 ..
B03070 I-W CONS COMMBOARD1 X=18.892 Y=-15.23 Z=0
 A=393.5 AZ=159.88 TILT=180 N-T RM02048 ..

RM03011=SPACE S-C=CondType1
 A=3.24  V=17.496  AZ=0   Z=10.8 ..
AW03314 E-W CONS EW1 X=61.657 Y=-6.38
 W=1.2 H=5.4 AZ=339.88 S-S YES ..
AW03034 E-W CONS EW1 X=60.53 Y=-6.792
 W=2.7 H=5.4 AZ=249.88 S-S YES ..
D03010 Door CONS DR1 X=0.8 Y=0.001
 W=0.799 H=2.099 ..
AW03315 E-W CONS EW1 X=61.459 Y=-9.328
 W=1.2 H=5.4 AZ=159.88 S-S YES ..
I03041 I-W CONS IW1 X=61.657 Y=-6.38
 W=2.7 H=5.4 AZ=249.88 N-T RM03014 ..
R03011 ROOF CONS RF1 X=61.459 Y=-9.328 Z=5.4
 W=2.7 H=1.2 AZ=159.88 TILT=0 ..
B03020 I-W CONS COMMBOARD1 X=61.459 Y=-9.328 Z=0
 A=3.24 AZ=159.88 TILT=180 N-T RM02008 ..

RM03012=SPACE S-C=CondType1
 A=1.95  V=10.53  AZ=0   Z=10.8 ..
AW03308 E-W CONS EW1 X=58.432 Y=-1.065
 W=1.3 H=5.4 AZ=249.88 S-S YES ..
I03318 I-W CONS IW1 X=58.432 Y=-1.065
 W=1.5 H=5.4 AZ=159.88 N-T RM03019 ..
I03311 I-W CONS IW1 X=58.879 Y=-2.285
 W=1.5 H=5.4 AZ=159.88 N-T RM03018 ..
D03090 I-W CONS DR1 X=59.218 Y=0
 A=1.68 N-T RM03018 ..
I03313 I-W CONS IW1 X=59.84 Y=-0.549
 W=1.3 H=5.4 AZ=249.88 N-T RM03018 ..
R03012 ROOF CONS RF1 X=58.879 Y=-2.285 Z=5.4
 W=1.5 H=1.3 AZ=159.88 TILT=0 ..
B03021 I-W CONS COMMBOARD1 X=58.879 Y=-2.285 Z=0
 A=1.95 AZ=159.88 TILT=180 N-T RM02009 ..

RM03013=SPACE S-C=CondType1
 A=4.4  V=23.76  AZ=0   Z=10.8 ..
AW03113 E-W CONS EW1 X=61.437 Y=-2.946
 W=2 H=5.4 AZ=249.88 S-S YES ..
D03023 Door CONS DR1 X=0.1 Y=0.001
 W=1.099 H=2.099 ..
I03109 I-W CONS IW1 X=63.503 Y=-2.189
 W=2.2 H=5.4 AZ=339.88 N-T RM03018 ..
I03115 I-W CONS IW1 X=62.125 Y=-4.824
 W=2.2 H=5.4 AZ=159.88 N-T RM03017 ..
I03114 I-W CONS IW1 X=63.503 Y=-2.189
 W=2 H=5.4 AZ=249.88 N-T RM03017 ..
R03013 ROOF CONS RF1 X=62.125 Y=-4.824 Z=5.4
 W=2.2 H=2 AZ=159.88 TILT=0 ..
B03022 I-W CONS COMMBOARD1 X=62.125 Y=-4.824 Z=0
 A=4.399 AZ=159.88 TILT=180 N-T RM02010 ..

RM03014=SPACE S-C=CondType1
 A=11.205  V=60.507  AZ=0   Z=10.8 ..
AW03038 E-W CONS EW1 X=62.573 Y=-6.044
 W=0.975 H=5.4 AZ=339.88 S-S YES ..
AW03035 E-W CONS EW1 X=62.586 Y=-8.915
 W=4.15 H=5.4 AZ=159.88 S-S YES ..
D03011 Door CONS DR1 X=1.55 Y=0.001
 W=1.499 H=2.099 ..
I03316 I-W CONS IW1 X=62.573 Y=-6.044
 W=3.175 H=5.4 AZ=159.88 N-T RM03017 ..
I03040 I-W CONS IW1 X=65.554 Y=-4.952
 W=2.7 H=5.4 AZ=249.88 N-T RM03016 ..
W03012-1 I-W CONS IWIN1 X=65.849 Y=0
 A=4.235 N-T RM03016 ..
R03014 ROOF CONS RF1 X=62.586 Y=-8.915 Z=5.4
 W=4.15 H=2.7 AZ=159.88 TILT=0 ..
B03023 I-W CONS COMMBOARD1 X=62.586 Y=-8.915 Z=0
 A=11.204 AZ=159.88 TILT=180 N-T RM02011 ..

RM03015=SPACE S-C=CondType2
 A=396.16  V=2139.26  AZ=0   Z=10.8 ..
AW03319 E-W CONS EW1 X=71.029 Y=-9.869
 W=34 H=5.4 AZ=339.88 S-S YES ..
WIN03092  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0.5 Y=0
 W=3.799 H=4.299 ..
WIN03093  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=12.9 Y=0
 W=3.799 H=4.299 ..
WIN03094  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=4.5 Y=0
 W=3.799 H=4.299 ..
WIN03095  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=8.9 Y=0
 W=3.799 H=4.299 ..
WIN03096  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=21.3 Y=0
 W=3.799 H=4.299 ..
WIN03097  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=25.7 Y=0
 W=3.799 H=4.299 ..
WIN03098  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=17.3 Y=0
 W=3.799 H=4.299 ..
WIN03099  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=29.7 Y=0
 W=3.649 H=4.299 ..
AW03191 E-W CONS EW1 X=37.692 Y=-24.105
 W=6.9 H=5.4 AZ=249.88 S-S YES ..
WIN03111  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-6
 X=2.6 Y=0
 W=3.799 H=4.299 ..
WIN03114  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-6
 X=1.4 Y=0
 W=0.999 H=4.299 ..
AW03298 E-W CONS EW1 X=40.065 Y=-30.584
 W=10.3 H=5.4 AZ=159.88 S-S YES ..
WIN03085  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-32
 X=2.5 Y=0
 W=4.799 H=4.299 ..
AW03085 E-W CONS EW1 X=49.737 Y=-27.041
 W=0.3 H=5.4 AZ=249.88 S-S YES ..
AW03088 E-W CONS EW2 X=49.84 Y=-27.323
 W=8.4 H=5.4 AZ=249.88 S-S YES ..
WALL03088  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-2
 X=0 Y=0
 W=8.399 H=4.481 ..
AW03086 E-W CONS EW2 X=52.73 Y=-35.21
 W=9.4 H=5.4 AZ=159.88 S-S YES ..
WALL03086  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-34
 X=0 Y=0
 W=9.399 H=4.48 ..
AW03087 E-W CONS EW2 X=61.556 Y=-31.976
 W=8.4 H=5.4 AZ=69.88 S-S YES ..
WALL03087  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-33
 X=0 Y=0
 W=8.399 H=4.481 ..
AW03002 E-W CONS EW1 X=58.666 Y=-24.089
 W=0.3 H=5.4 AZ=69.88 S-S YES ..
AW03001 E-W CONS EW1 X=58.563 Y=-23.807
 W=16.5 H=5.4 AZ=159.88 S-S YES ..
WIN03001  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-32
 X=10.45 Y=0
 W=5.949 H=4.299 ..
WIN03002  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-32
 X=2.05 Y=0
 W=4.699 H=4.299 ..
AW03307 E-W CONS EW1 X=74.056 Y=-18.132
 W=8.8 H=5.4 AZ=69.88 S-S YES ..
WIN03089  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-35
 X=2.6 Y=0
 W=4.799 H=4.299 ..
R03015 ROOF CONS RF1 X=43.058 Y=-38.753 Z=5.4
 W=34 H=11.652 AZ=159.88 TILT=0 ..
B03090 I-W CONS COMMBOARD1 X=43.058 Y=-38.753 Z=0
 A=396.152 AZ=159.88 TILT=180 N-T RM02052 ..

RM03016=SPACE S-C=CondType1
 A=9.315  V=50.301  AZ=0   Z=10.8 ..
AW03036 E-W CONS EW1 X=66.483 Y=-7.487
 W=3.45 H=5.4 AZ=159.88 S-S YES ..
AW03310 E-W CONS EW1 X=69.722 Y=-6.301
 W=2.7 H=5.4 AZ=69.88 S-S YES ..
I03037 I-W CONS IW1 X=65.554 Y=-4.952
 W=3.45 H=5.4 AZ=159.88 N-T RM03017 ..
R03016 ROOF CONS RF1 X=66.483 Y=-7.487 Z=5.4
 W=3.45 H=2.7 AZ=159.88 TILT=0 ..
B03024 I-W CONS COMMBOARD1 X=66.483 Y=-7.487 Z=0
 A=9.314 AZ=159.88 TILT=180 N-T RM02012 ..

RM03017=SPACE S-C=CondType1
 A=17.868  V=96.485  AZ=0   Z=10.8 ..
AW03092 E-W CONS EW1 X=68.052 Y=-0.869
 W=0.3 H=5.4 AZ=339.88 S-S YES ..
AW03096 E-W CONS EW1 X=67.77 Y=-0.972
 W=0.325 H=5.4 AZ=69.88 S-S YES ..
AW03111 E-W CONS EW1 X=62.125 Y=-4.824
 W=1.3 H=5.4 AZ=249.88 S-S YES ..
D03021 Door CONS DR1 X=0.1 Y=0.001
 W=0.999 H=2.099 ..
AW03097 E-W CONS EW1 X=68.793 Y=-3.765
 W=1.625 H=5.4 AZ=69.88 S-S YES ..
AW03094 E-W CONS EW1 X=68.234 Y=-2.239
 W=0.3 H=5.4 AZ=159.88 S-S YES ..
AW03100 E-W CONS EW2 X=68.516 Y=-2.136
 W=1.35 H=5.4 AZ=69.88 S-S YES ..
WALL03100  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-4
 X=0 Y=0
 W=1.349 H=4.483 ..
I03317 I-W CONS IW1 X=67.658 Y=-0.667
 W=4.425 H=5.4 AZ=339.88 N-T RM03018 ..
R03017 ROOF CONS RF1 X=62.573 Y=-6.044 Z=5.4
 W=6.625 H=2.697 AZ=159.88 TILT=0 ..
B03025 I-W CONS COMMBOARD1 X=62.573 Y=-6.044 Z=0
 A=17.866 AZ=159.88 TILT=180 N-T RM02013 ..

RM03018=SPACE S-C=CondType1
 A=23.095  V=124.713  AZ=0   Z=10.8 ..
AW03093 E-W CONS EW1 X=67.226 Y=1.385
 W=0.3 H=5.4 AZ=339.88 S-S YES ..
AW03090 E-W CONS EW1 X=66.944 Y=1.282
 W=0.725 H=5.4 AZ=69.88 S-S YES ..
AW03110 E-W CONS EW1 X=58.879 Y=-2.285
 W=1.5 H=5.4 AZ=249.88 S-S YES ..
AW03112 E-W CONS EW1 X=59.395 Y=-3.694
 W=2.175 H=5.4 AZ=159.88 S-S YES ..
D03022 Door CONS DR1 X=1.075 Y=0.001
 W=0.999 H=2.099 ..
AW03091 E-W CONS EW1 X=67.658 Y=-0.667
 W=0.725 H=5.4 AZ=69.88 S-S YES ..
AW03095 E-W CONS EW1 X=67.409 Y=0.014
 W=0.3 H=5.4 AZ=159.88 S-S YES ..
AW03099 E-W CONS EW2 X=67.69 Y=0.117
 W=1.35 H=5.4 AZ=69.88 S-S YES ..
WALL03099  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-33
 X=0 Y=0
 W=1.349 H=4.483 ..
I03312 I-W CONS IW1 X=59.84 Y=-0.549
 W=7.3 H=5.4 AZ=159.88 N-T RM03019 ..
R03018 ROOF CONS RF1 X=59.395 Y=-3.694 Z=5.4
 W=8.8 H=2.624 AZ=159.88 TILT=0 ..
B03026 I-W CONS COMMBOARD1 X=59.395 Y=-3.694 Z=0
 A=23.093 AZ=159.88 TILT=180 N-T RM02014 ..

RM03019=SPACE S-C=CondType3
 A=75.78  V=409.212  AZ=0   Z=10.8 ..
AW03144 E-W CONS EW1 X=56.609 Y=3.912
 W=5.3 H=5.4 AZ=249.88 S-S YES ..
D03034 Door CONS DR1 X=2.6 Y=0.001
 W=2.199 H=2.099 ..
D03035 Door CONS DR1 X=0.4 Y=0.001
 W=2.199 H=2.099 ..
AW03098 E-W CONS EW1 X=66.695 Y=1.962
 W=1.5 H=5.4 AZ=69.88 S-S YES ..
AW03330 E-W CONS EW1 X=66.179 Y=3.371
 W=0.3 H=5.4 AZ=159.88 S-S YES ..
AW03101 E-W CONS EW2 X=66.426 Y=3.568
 W=4.875 H=5.4 AZ=69.88 S-S YES ..
WALL03101  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-33
 X=0 Y=0
 W=4.874 H=4.481 ..
AW03329 E-W CONS EW2 X=64.749 Y=8.145
 W=1.1 H=5.4 AZ=69.88 S-S YES ..
WALL03329  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-4
 X=0 Y=0
 W=1.099 H=4.484 ..
AW03047 E-W CONS EW2 X=64.371 Y=9.178
 W=0.125 H=5.4 AZ=69.88 S-S YES ..
WALL03047  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-4
 X=0 Y=0
 W=0.124 H=4.516 ..
I03048 I-W CONS IW1 X=64.328 Y=9.296
 W=0.3 H=5.4 AZ=339.88 N-T RM03068 ..
I03046 I-W CONS IW1 X=64.046 Y=9.193
 W=0.7 H=5.4 AZ=69.88 N-T RM03068 ..
I03045 I-W CONS IW1 X=63.805 Y=9.85
 W=8.8 H=5.4 AZ=339.88 N-T RM03020 ..
I03309 I-W CONS IW1 X=55.542 Y=6.823
 W=3.1 H=5.4 AZ=249.88 N-T RM03020 ..
R03019 ROOF CONS RF1 X=58.432 Y=-1.065 Z=5.4
 W=8.8 H=8.611 AZ=159.88 TILT=0 ..
B03009 I-W CONS COMMBOARD1 X=62.039 Y=4.729 Z=0
 A=13.017 AZ=159.88 TILT=180 N-T RM02047 ..
B03010 I-W CONS COMMBOARD1 X=63.45 Y=0.88 Z=0
 A=13.017 AZ=159.88 TILT=180 N-T RM02047 ..
B03067 I-W CONS COMMBOARD1 X=58.432 Y=-1.065 Z=0
 A=75.778 AZ=159.88 TILT=180 N-T RM02047 ..

RM03020=SPACE S-C=CondType2
 A=185.475  V=1001.57  AZ=0   Z=10.8 ..
AW03089 E-W CONS EW2 X=61.094 Y=18.122
 W=10.8 H=5.4 AZ=339.88 S-S YES ..
WALL03089  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=10.799 H=4.48 ..
AW03077 E-W CONS EW1 X=50.954 Y=14.407
 W=0.3 H=5.4 AZ=249.88 S-S YES ..
AW03076 E-W CONS EW1 X=51.057 Y=14.125
 W=1 H=5.4 AZ=339.88 S-S YES ..
AW03078 E-W CONS EW1 X=50.118 Y=13.781
 W=0.3 H=5.4 AZ=69.88 S-S YES ..
AW03103 E-W CONS EW2 X=50.015 Y=14.063
 W=1.4 H=5.4 AZ=339.88 S-S YES ..
WALL03103  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=1.399 H=4.483 ..
AW03080 E-W CONS EW1 X=48.7 Y=13.581
 W=0.3 H=5.4 AZ=249.88 S-S YES ..
AW03079 E-W CONS EW1 X=48.803 Y=13.3
 W=1 H=5.4 AZ=339.88 S-S YES ..
AW03081 E-W CONS EW1 X=47.864 Y=12.956
 W=0.3 H=5.4 AZ=69.88 S-S YES ..
AW03102 E-W CONS EW2 X=47.761 Y=13.237
 W=1.4 H=5.4 AZ=339.88 S-S YES ..
WALL03102  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=1.399 H=4.483 ..
AW03083 E-W CONS EW1 X=46.446 Y=12.756
 W=0.3 H=5.4 AZ=249.88 S-S YES ..
AW03082 E-W CONS EW1 X=46.55 Y=12.474
 W=1.9 H=5.4 AZ=339.88 S-S YES ..
AW03084 E-W CONS EW1 X=44.766 Y=11.821
 W=13 H=5.4 AZ=249.88 S-S YES ..
D03015 Door CONS DR1 X=5.05 Y=0.001
 W=2.299 H=2.099 ..
AW03143 E-W CONS EW1 X=49.237 Y=-0.386
 W=5.65 H=5.4 AZ=159.88 S-S YES ..
WIN03033  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-5
 X=0.1 Y=0.9
 W=1.049 H=4.299 ..
WIN03112  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-30
 X=1.35 Y=0
 W=3.799 H=4.299 ..
AW03145 E-W CONS EW1 X=54.543 Y=1.557
 W=1.5 H=5.4 AZ=69.88 S-S YES ..
AW03146 E-W CONS EW1 X=54.027 Y=2.966
 W=2.75 H=5.4 AZ=159.88 S-S YES ..
AW03328 E-W CONS EW2 X=63.95 Y=10.329
 W=8.3 H=5.4 AZ=69.88 S-S YES ..
WALL03328  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-33
 X=0 Y=0
 W=8.299 H=4.481 ..
I03043 I-W CONS IW1 X=63.668 Y=10.225
 W=0.4 H=5.4 AZ=249.88 N-T RM03068 ..
I03044 I-W CONS IW1 X=63.95 Y=10.329
 W=0.3 H=5.4 AZ=339.88 N-T RM03068 ..
R03020 ROOF CONS RF1 X=49.237 Y=-0.386 Z=5.4
 W=13 H=14.267 AZ=159.88 TILT=0 ..
B03071 I-W CONS COMMBOARD1 X=49.237 Y=-0.386 Z=0
 A=185.263 AZ=159.88 TILT=180 N-T RM02048 ..
B03091 E-W CONS ABOARD1 X=52.371 Y=14.607 Z=0
 W=0.7 H=0.3 AZ=69.88 TILT=180 ..

RM03021=SPACE S-C=CondType1
 A=4.18  V=22.572  AZ=0   Z=10.8 ..
AW03260 E-W CONS EW1 X=89.318 Y=-12.115
 W=1.9 H=5.4 AZ=249.88 S-S YES ..
I03129 I-W CONS IW1 X=91.384 Y=-11.358
 W=2.2 H=5.4 AZ=339.88 N-T RM03029 ..
I03127 I-W CONS IW1 X=92.037 Y=-13.142
 W=2.2 H=5.4 AZ=339.88 N-T RM03023 ..
I03126 I-W CONS IW1 X=92.037 Y=-13.142
 W=1.9 H=5.4 AZ=69.88 N-T RM03023 ..
R03021 ROOF CONS RF1 X=89.971 Y=-13.899 Z=5.4
 W=2.2 H=1.9 AZ=159.88 TILT=0 ..
B03027 I-W CONS COMMBOARD1 X=89.765 Y=-13.336 Z=0
 A=2.86 AZ=159.88 TILT=180 N-T RM02015 ..
B03030 I-W CONS COMMBOARD1 X=89.971 Y=-13.899 Z=0
 A=1.319 AZ=159.88 TILT=180 N-T RM02017 ..

RM03022=SPACE S-C=CondType1
 A=9.315  V=50.301  AZ=0   Z=10.8 ..
AW03008 E-W CONS EW1 X=85.637 Y=-2.068
 W=2.7 H=5.4 AZ=249.88 S-S YES ..
I03006 I-W CONS IW1 X=88.877 Y=-0.881
 W=3.45 H=5.4 AZ=339.88 N-T RM03024 ..
I03026 I-W CONS IW1 X=89.805 Y=-3.416
 W=3.45 H=5.4 AZ=339.88 N-T RM03029 ..
I03028 I-W CONS IW1 X=88.877 Y=-0.881
 W=2.7 H=5.4 AZ=249.88 N-T RM03026 ..
W03008-1 I-W CONS IWIN1 X=88.856 Y=0
 A=4.235 N-T RM03026 ..
R03022 ROOF CONS RF1 X=86.566 Y=-4.603 Z=5.4
 W=3.45 H=2.7 AZ=159.88 TILT=0 ..
B03028 I-W CONS COMMBOARD1 X=86.566 Y=-4.603 Z=0
 A=9.314 AZ=159.88 TILT=180 N-T RM02016 ..

RM03023=SPACE S-C=CondType3
 A=36.031  V=194.567  AZ=0   Z=10.8 ..
AW03125 E-W CONS EW1 X=89.971 Y=-13.899
 W=6.9 H=5.4 AZ=249.88 S-S YES ..
AW03200 E-W CONS EW1 X=92.345 Y=-20.378
 W=4.4 H=5.4 AZ=159.88 S-S YES ..
WIN03044  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-36
 X=0.65 Y=0.9
 W=2.299 H=1.499 ..
I03123 I-W CONS IW1 X=93.778 Y=-10.481
 W=2.55 H=5.4 AZ=339.88 N-T RM03029 ..
D03026 I-W CONS DR1 X=92.1 Y=0
 A=4.62 N-T RM03029 ..
I03130 I-W CONS IW1 X=94.915 Y=-14.601
 W=4.54 H=5.4 AZ=249.88 N-T RM03027 ..
I03131 I-W CONS IW1 X=94.915 Y=-14.601
 W=0.35 H=5.4 AZ=159.88 N-T RM03027 ..
I03132 I-W CONS IW1 X=93.778 Y=-10.481
 W=4.26 H=5.4 AZ=249.88 N-T RM03027 ..
R03023 ROOF CONS RF1 X=92.345 Y=-20.378 Z=5.4
 W=6.9 H=5.222 AZ=159.88 TILT=0 ..
B03001 I-W CONS COMMBOARD1 X=92.405 Y=-20.25 Z=0
 A=8.82 AZ=159.88 TILT=180 N-T RM02017 ..
B03029 I-W CONS COMMBOARD1 X=92.345 Y=-20.378 Z=0
 A=34.539 AZ=159.88 TILT=180 N-T RM02017 ..
B03035 I-W CONS COMMBOARD1 X=94.915 Y=-14.601 Z=0
 A=1.491 AZ=159.88 TILT=180 N-T RM02021 ..

RM03024=SPACE S-C=CondType1
 A=18.124  V=97.868  AZ=0   Z=10.8 ..
AW03009 E-W CONS EW2 X=84.203 Y=0.975
 W=1.45 H=5.4 AZ=249.88 S-S YES ..
WALL03009  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-2
 X=0 Y=0
 W=1.449 H=4.483 ..
AW03069 E-W CONS EW1 X=84.702 Y=-0.387
 W=0.1 H=5.4 AZ=249.88 S-S YES ..
AW03070 E-W CONS EW1 X=84.736 Y=-0.481
 W=0.3 H=5.4 AZ=159.88 S-S YES ..
AW03285 E-W CONS EW1 X=85.018 Y=-0.377
 W=1.8 H=5.4 AZ=249.88 S-S YES ..
I03013 I-W CONS IW1 X=91.3 Y=1.445
 W=2.1 H=5.4 AZ=339.88 N-T RM03025 ..
I03021 I-W CONS IW1 X=88.64 Y=2.6
 W=2 H=5.4 AZ=249.88 N-T RM03025 ..
I03017 I-W CONS IW1 X=84.203 Y=0.975
 W=4.725 H=5.4 AZ=159.88 N-T RM03030 ..
I03012 I-W CONS IW1 X=91.764 Y=0.177
 W=3.075 H=5.4 AZ=339.88 N-T RM03026 ..
I03022 I-W CONS IW1 X=91.3 Y=1.445
 W=1.35 H=5.4 AZ=249.88 N-T RM03029 ..
D03006 I-W CONS DR1 X=91.027 Y=0
 A=2.1 N-T RM03029 ..
R03024 ROOF CONS RF1 X=85.355 Y=-2.171 Z=5.4
 W=6.525 H=2.778 AZ=159.88 TILT=0 ..
B03031 I-W CONS COMMBOARD1 X=85.355 Y=-2.171 Z=0
 A=18.122 AZ=159.88 TILT=180 N-T RM02018 ..

RM03025=SPACE S-C=CondType1
 A=4.2  V=22.68  AZ=0   Z=10.8 ..
I03014 I-W CONS IW1 X=88.64 Y=2.6
 W=2.1 H=5.4 AZ=159.88 N-T RM03030 ..
I03020 I-W CONS IW1 X=90.612 Y=3.322
 W=2 H=5.4 AZ=249.88 N-T RM03029 ..
D03005 I-W CONS DR1 X=90.326 Y=0
 A=2.31 N-T RM03029 ..
R03025 ROOF CONS RF1 X=89.328 Y=0.722 Z=5.4
 W=2.1 H=2 AZ=159.88 TILT=0 ..
B03032 I-W CONS COMMBOARD1 X=89.328 Y=0.722 Z=0
 A=4.2 AZ=159.88 TILT=180 N-T RM02019 ..

RM03026=SPACE S-C=CondType1
 A=11.205  V=60.507  AZ=0   Z=10.8 ..
I03005 I-W CONS IW1 X=92.773 Y=0.547
 W=1.075 H=5.4 AZ=339.88 N-T RM03029 ..
I03025 I-W CONS IW1 X=93.702 Y=-1.989
 W=4.15 H=5.4 AZ=339.88 N-T RM03029 ..
D03007 I-W CONS DR1 X=91.253 Y=0
 A=3.15 N-T RM03029 ..
I03027 I-W CONS IW1 X=92.773 Y=0.547
 W=2.7 H=5.4 AZ=249.88 N-T RM03028 ..
R03026 ROOF CONS RF1 X=89.805 Y=-3.416 Z=5.4
 W=4.15 H=2.7 AZ=159.88 TILT=0 ..
B03033 I-W CONS COMMBOARD1 X=89.805 Y=-3.416 Z=0
 A=11.204 AZ=159.88 TILT=180 N-T RM02020 ..

RM03027=SPACE S-C=CondType3
 A=37.229  V=201.037  AZ=0   Z=10.8 ..
AW03128 E-W CONS EW1 X=96.476 Y=-18.864
 W=4.4 H=5.4 AZ=159.88 S-S YES ..
WIN03027  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-36
 X=1.45 Y=0.9
 W=2.299 H=1.499 ..
AW03118 E-W CONS EW1 X=100.608 Y=-17.351
 W=3.9 H=5.4 AZ=69.88 S-S YES ..
I03259 I-W CONS IW1 X=97.581 Y=-9.088
 W=4.05 H=5.4 AZ=339.88 N-T RM03029 ..
D03066 I-W CONS DR1 X=95.371 Y=0
 A=4.62 N-T RM03029 ..
I03177 I-W CONS IW1 X=98.578 Y=-11.811
 W=2 H=5.4 AZ=249.88 N-T RM03029 ..
I03220 I-W CONS IW1 X=97.581 Y=-9.088
 W=2.9 H=5.4 AZ=249.88 N-T RM03031 ..
R03027 ROOF CONS RF1 X=96.476 Y=-18.864 Z=5.4
 W=8.8 H=4.231 AZ=159.88 TILT=0 ..
B03004 I-W CONS COMMBOARD1 X=96.536 Y=-18.736 Z=0
 A=8.82 AZ=159.88 TILT=180 N-T RM02021 ..
B03034 I-W CONS COMMBOARD1 X=96.476 Y=-18.864 Z=0
 A=37.228 AZ=159.88 TILT=180 N-T RM02021 ..

RM03028=SPACE S-C=CondType1
 A=3.24  V=17.496  AZ=0   Z=10.8 ..
I03023 I-W CONS IW1 X=93.9 Y=0.959
 W=1.2 H=5.4 AZ=339.88 N-T RM03029 ..
I03286 I-W CONS IW1 X=94.829 Y=-1.576
 W=1.2 H=5.4 AZ=339.88 N-T RM03029 ..
I03029 I-W CONS IW1 X=93.9 Y=0.959
 W=2.7 H=5.4 AZ=249.88 N-T RM03029 ..
D03009 I-W CONS DR1 X=93.983 Y=0
 A=1.68 N-T RM03029 ..
R03028 ROOF CONS RF1 X=93.702 Y=-1.989 Z=5.4
 W=2.7 H=1.2 AZ=159.88 TILT=0 ..
B03036 I-W CONS COMMBOARD1 X=93.702 Y=-1.989 Z=0
 A=3.24 AZ=159.88 TILT=180 N-T RM02022 ..

RM03029=SPACE S-C=CondType4
 A=1398.5  V=7551.88  AZ=0   Z=10.8 ..
AW03294 E-W CONS EW1 X=128.349 Y=29.022
 W=10.9 H=5.4 AZ=339.88 S-S YES ..
WIN03084  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=2.6 Y=0.9
 W=7.099 H=3.849 ..
AW03073 E-W CONS EW1 X=118.114 Y=25.273
 W=3.851 H=5.4 AZ=249.88 S-S YES ..
AW03075 E-W CONS EW2 X=119.439 Y=21.657
 W=4.949 H=5.4 AZ=249.88 S-S YES ..
WALL03075  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-2
 X=0 Y=0
 W=4.948 H=4.481 ..
AW03074 E-W CONS EW2 X=121.142 Y=17.01
 W=5.9 H=5.4 AZ=339.88 S-S YES ..
WALL03074  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=5.899 H=4.481 ..
AW03222 E-W CONS EW1 X=115.602 Y=14.98
 W=8.8 H=5.4 AZ=69.88 S-S YES ..
WIN03050  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-37
 X=0.5 Y=0.9
 W=7.199 H=3.849 ..
AW03054 E-W CONS EW1 X=112.574 Y=23.243
 W=6.9 H=5.4 AZ=339.88 S-S YES ..
AW03068 E-W CONS EW1 X=106.096 Y=20.87
 W=0.3 H=5.4 AZ=69.88 S-S YES ..
AW03067 E-W CONS EW2 X=105.992 Y=21.151
 W=1.4 H=5.4 AZ=339.88 S-S YES ..
WALL03067  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=1.399 H=4.483 ..
AW03066 E-W CONS EW1 X=104.678 Y=20.67
 W=0.3 H=5.4 AZ=249.88 S-S YES ..
AW03065 E-W CONS EW1 X=104.781 Y=20.388
 W=1 H=5.4 AZ=339.88 S-S YES ..
AW03064 E-W CONS EW1 X=103.842 Y=20.044
 W=0.3 H=5.4 AZ=69.88 S-S YES ..
AW03063 E-W CONS EW2 X=103.739 Y=20.326
 W=1.4 H=5.4 AZ=339.88 S-S YES ..
WALL03063  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=1.399 H=4.483 ..
AW03062 E-W CONS EW1 X=102.424 Y=19.844
 W=0.3 H=5.4 AZ=249.88 S-S YES ..
AW03060 E-W CONS EW1 X=102.527 Y=19.562
 W=1 H=5.4 AZ=339.88 S-S YES ..
AW03061 E-W CONS EW1 X=101.588 Y=19.218
 W=0.3 H=5.4 AZ=69.88 S-S YES ..
AW03059 E-W CONS EW2 X=101.485 Y=19.5
 W=1.4 H=5.4 AZ=339.88 S-S YES ..
WALL03059  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=1.399 H=4.483 ..
AW03058 E-W CONS EW1 X=100.171 Y=19.019
 W=0.3 H=5.4 AZ=249.88 S-S YES ..
AW03056 E-W CONS EW1 X=100.274 Y=18.737
 W=1 H=5.4 AZ=339.88 S-S YES ..
AW03057 E-W CONS EW1 X=99.335 Y=18.393
 W=0.3 H=5.4 AZ=69.88 S-S YES ..
AW03055 E-W CONS EW2 X=99.232 Y=18.675
 W=20.2 H=5.4 AZ=339.88 S-S YES ..
WALL03055  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=20.199 H=4.48 ..
AW03295 E-W CONS EW2 X=80.264 Y=11.726
 W=8.65 H=5.4 AZ=249.88 S-S YES ..
WALL03295  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-2
 X=0 Y=0
 W=8.649 H=4.481 ..
AW03209 E-W CONS EW1 X=86.566 Y=-4.603
 W=0.3 H=5.4 AZ=339.88 S-S YES ..
AW03210 E-W CONS EW1 X=86.284 Y=-4.706
 W=0.2 H=5.4 AZ=249.88 S-S YES ..
AW03052 E-W CONS EW2 X=86.353 Y=-4.894
 W=7.2 H=5.4 AZ=249.88 S-S YES ..
WALL03052  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-2
 X=0 Y=0
 W=7.199 H=4.481 ..
AW03053 E-W CONS EW1 X=88.83 Y=-11.654
 W=0.6 H=5.4 AZ=249.88 S-S YES ..
AW03208 E-W CONS EW1 X=89.036 Y=-12.218
 W=0.3 H=5.4 AZ=159.88 S-S YES ..
AW03291 E-W CONS EW1 X=99.266 Y=-13.689
 W=3.8 H=5.4 AZ=159.88 S-S YES ..
WIN03081  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-32
 X=0.4 Y=0
 W=3.149 H=4.299 ..
AW03119 E-W CONS EW1 X=102.834 Y=-12.381
 W=3.9 H=5.4 AZ=249.88 S-S YES ..
AW03258 E-W CONS EW1 X=104.176 Y=-16.043
 W=25.6 H=5.4 AZ=159.88 S-S YES ..
WIN03065  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-1
 X=21.5 Y=0.9
 W=2.899 H=3.849 ..
WIN03106  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-32
 X=17.1 Y=0
 W=3.799 H=4.299 ..
WIN03107  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-32
 X=13.1 Y=0
 W=3.799 H=4.299 ..
WIN03108  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-32
 X=8.7 Y=0
 W=3.799 H=4.299 ..
WIN03109  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-32
 X=4.7 Y=0
 W=3.799 H=4.299 ..
WIN03110  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-32
 X=0.1 Y=0
 W=3.999 H=4.299 ..
AW03117 E-W CONS EW1 X=128.214 Y=-7.237
 W=3.9 H=5.4 AZ=69.88 S-S YES ..
AW03257 E-W CONS EW1 X=126.872 Y=-3.575
 W=3.8 H=5.4 AZ=159.88 S-S YES ..
D03064 Door CONS DR1 X=1.55 Y=0.001
 W=1.499 H=2.099 ..
AW03261 E-W CONS EW2 X=137.018 Y=5.36
 W=8 H=5.4 AZ=69.88 S-S YES ..
WALL03261  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-38
 X=0 Y=0
 W=7.999 H=4.481 ..
AW03266 E-W CONS EW1 X=131.239 Y=21.135
 W=8.4 H=5.4 AZ=69.88 S-S YES ..
WIN03072  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-39
 X=1 Y=0.9
 W=4.749 H=3.849 ..
I03010 I-W CONS IW1 X=90.376 Y=6.218
 W=7.6 H=5.4 AZ=339.88 N-T RM03030 ..
I03018 I-W CONS IW1 X=91.785 Y=6.734
 W=1.5 H=5.4 AZ=339.88 N-T RM03069 ..
I03024 I-W CONS IW1 X=91.785 Y=6.734
 W=1.3 H=5.4 AZ=249.88 N-T RM03069 ..
I03015 I-W CONS IW1 X=92.232 Y=5.514
 W=1.5 H=5.4 AZ=249.88 N-T RM03030 ..
I03011 I-W CONS IW1 X=90.612 Y=3.322
 W=2.275 H=5.4 AZ=159.88 N-T RM03030 ..
D03003 I-W CONS DR1 X=91.767 Y=0
 A=2.1 N-T RM03030 ..
I03030 I-W CONS IW1 X=93.264 Y=2.697
 W=1.85 H=5.4 AZ=249.88 N-T RM03029 ..
I03179 I-W CONS IW1 X=98.848 Y=-8.623
 W=1.35 H=5.4 AZ=339.88 N-T RM03031 ..
I03180 I-W CONS IW1 X=98.848 Y=-8.623
 W=2.9 H=5.4 AZ=249.88 N-T RM03031 ..
I03178 I-W CONS IW1 X=99.846 Y=-11.346
 W=1.35 H=5.4 AZ=339.88 N-T RM03031 ..
I03173 I-W CONS IW1 X=129.752 Y=-0.39
 W=2 H=5.4 AZ=249.88 N-T RM03033 ..
I03174 I-W CONS IW1 X=128.485 Y=-0.855
 W=1.35 H=5.4 AZ=159.88 N-T RM03032 ..
I03176 I-W CONS IW1 X=127.487 Y=1.868
 W=2.9 H=5.4 AZ=249.88 N-T RM03032 ..
I03175 I-W CONS IW1 X=127.487 Y=1.868
 W=1.35 H=5.4 AZ=159.88 N-T RM03032 ..
I03198 I-W CONS IW1 X=132.886 Y=3.846
 W=4.4 H=5.4 AZ=339.88 N-T RM03033 ..
D03043 I-W CONS DR1 X=129.852 Y=0
 A=4.62 N-T RM03033 ..
I03293 I-W CONS IW1 X=137.018 Y=5.36
 W=4.4 H=5.4 AZ=339.88 N-T RM03035 ..
D03083 I-W CONS DR1 X=133.978 Y=0
 A=4.62 N-T RM03035 ..
I03218 I-W CONS IW1 X=134.266 Y=12.872
 W=1.65 H=5.4 AZ=339.88 N-T RM03036 ..
I03188 I-W CONS IW1 X=132.717 Y=12.304
 W=1.35 H=5.4 AZ=339.88 N-T RM03034 ..
I03284 I-W CONS IW1 X=131.449 Y=11.84
 W=2.7 H=5.4 AZ=69.88 N-T RM03034 ..
I03280 I-W CONS IW1 X=130.52 Y=14.375
 W=1.4 H=5.4 AZ=69.88 N-T RM03037 ..
I03151 I-W CONS IW1 X=130.039 Y=15.69
 W=1.7 H=5.4 AZ=69.88 N-T RM03038 ..
I03281 I-W CONS IW1 X=129.454 Y=17.286
 W=3 H=5.4 AZ=69.88 N-T RM03039 ..
I03289 I-W CONS IW1 X=131.239 Y=21.135
 W=3 H=5.4 AZ=339.88 N-T RM03039 ..
R03029 ROOF CONS RF1 X=92.063 Y=-20.481 Z=5.4
 W=25.6 H=54.629 AZ=159.88 TILT=0 ..
B03073 I-W CONS COMMBOARD1 X=92.063 Y=-20.481 Z=0
 A=1398.48 AZ=159.88 TILT=180 N-T RM02049 ..

RM03030=SPACE S-C=CondType1
 A=23.53  V=127.062  AZ=0   Z=10.8 ..
AW03007 E-W CONS EW2 X=83.24 Y=3.604
 W=2.8 H=5.4 AZ=249.88 S-S YES ..
WALL03007  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-2
 X=0 Y=0
 W=2.799 H=4.482 ..
I03016 I-W CONS IW1 X=92.232 Y=5.514
 W=1.5 H=5.4 AZ=339.88 N-T RM03069 ..
D03004 I-W CONS DR1 X=91.231 Y=0
 A=1.68 N-T RM03069 ..
I03019 I-W CONS IW1 X=90.376 Y=6.218
 W=1.3 H=5.4 AZ=249.88 N-T RM03069 ..
R03030 ROOF CONS RF1 X=84.203 Y=0.975 Z=5.4
 W=9.1 H=2.586 AZ=159.88 TILT=0 ..
B03037 I-W CONS COMMBOARD1 X=84.203 Y=0.975 Z=0
 A=23.528 AZ=159.88 TILT=180 N-T RM02023 ..

RM03031=SPACE S-C=CondType1
 A=3.915  V=21.141  AZ=0   Z=10.8 ..
R03031 ROOF CONS RF1 X=98.578 Y=-11.811 Z=5.4
 W=2.9 H=1.35 AZ=159.88 TILT=0 ..
B03039 I-W CONS COMMBOARD1 X=98.578 Y=-11.811 Z=0
 A=3.915 AZ=159.88 TILT=180 N-T RM02025 ..

RM03032=SPACE S-C=CondType1
 A=3.915  V=21.141  AZ=0   Z=10.8 ..
I03219 I-W CONS IW1 X=128.755 Y=2.333
 W=2.9 H=5.4 AZ=249.88 N-T RM03033 ..
R03032 ROOF CONS RF1 X=128.485 Y=-0.855 Z=5.4
 W=2.9 H=1.35 AZ=159.88 TILT=0 ..
B03040 I-W CONS COMMBOARD1 X=128.485 Y=-0.855 Z=0
 A=3.915 AZ=159.88 TILT=180 N-T RM02026 ..

RM03033=SPACE S-C=CondType3
 A=38.72  V=209.088  AZ=0   Z=10.8 ..
AW03116 E-W CONS EW1 X=130.44 Y=-2.268
 W=3.9 H=5.4 AZ=249.88 S-S YES ..
AW03197 E-W CONS EW1 X=131.782 Y=-5.93
 W=4.4 H=5.4 AZ=159.88 S-S YES ..
WIN03042  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-36
 X=1.05 Y=0.9
 W=2.299 H=1.499 ..
I03199 I-W CONS IW1 X=132.886 Y=3.846
 W=8.8 H=5.4 AZ=249.88 N-T RM03035 ..
R03033 ROOF CONS RF1 X=131.782 Y=-5.93 Z=5.4
 W=8.8 H=4.4 AZ=159.88 TILT=0 ..
B03003 I-W CONS COMMBOARD1 X=131.842 Y=-5.802 Z=0
 A=8.82 AZ=159.88 TILT=180 N-T RM02027 ..
B03041 I-W CONS COMMBOARD1 X=131.782 Y=-5.93 Z=0
 A=38.719 AZ=159.88 TILT=180 N-T RM02027 ..

RM03034=SPACE S-C=CondType1
 A=3.645  V=19.683  AZ=0   Z=10.8 ..
I03187 I-W CONS IW1 X=131.788 Y=14.839
 W=1.35 H=5.4 AZ=339.88 N-T RM03037 ..
I03189 I-W CONS IW1 X=132.717 Y=12.304
 W=2.7 H=5.4 AZ=69.88 N-T RM03036 ..
R03034 ROOF CONS RF1 X=131.449 Y=11.84 Z=5.4
 W=2.7 H=1.35 AZ=159.88 TILT=0 ..
B03074 I-W CONS COMMBOARD1 X=131.449 Y=11.84 Z=0
 A=3.645 AZ=159.88 TILT=180 N-T RM02049 ..

RM03035=SPACE S-C=CondType3
 A=38.72  V=209.088  AZ=0   Z=10.8 ..
AW03292 E-W CONS EW1 X=135.913 Y=-4.417
 W=4.4 H=5.4 AZ=159.88 S-S YES ..
WIN03082  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-36
 X=1.9 Y=0.9
 W=2.299 H=1.499 ..
AW03290 E-W CONS EW1 X=140.045 Y=-2.903
 W=8.8 H=5.4 AZ=69.88 S-S YES ..
R03035 ROOF CONS RF1 X=135.913 Y=-4.417 Z=5.4
 W=8.8 H=4.4 AZ=159.88 TILT=0 ..
B03002 I-W CONS COMMBOARD1 X=135.973 Y=-4.289 Z=0
 A=8.82 AZ=159.88 TILT=180 N-T RM02028 ..
B03042 I-W CONS COMMBOARD1 X=135.913 Y=-4.417 Z=0
 A=38.719 AZ=159.88 TILT=180 N-T RM02028 ..

RM03036=SPACE S-C=CondType1
 A=4.455  V=24.057  AZ=0   Z=10.8 ..
AW03217 E-W CONS EW1 X=134.266 Y=12.872
 W=2.7 H=5.4 AZ=69.88 S-S YES ..
I03282 I-W CONS IW1 X=133.337 Y=15.407
 W=1.65 H=5.4 AZ=339.88 N-T RM03037 ..
R03036 ROOF CONS RF1 X=132.717 Y=12.304 Z=5.4
 W=2.7 H=1.65 AZ=159.88 TILT=0 ..
B03043 I-W CONS COMMBOARD1 X=132.717 Y=12.304 Z=0
 A=4.455 AZ=159.88 TILT=180 N-T RM02029 ..

RM03037=SPACE S-C=CondType1
 A=4.2  V=22.68  AZ=0   Z=10.8 ..
AW03283 E-W CONS EW1 X=133.337 Y=15.407
 W=1.4 H=5.4 AZ=69.88 S-S YES ..
D03079 Door CONS DR1 X=0.3 Y=0.001
 W=0.799 H=2.099 ..
I03153 I-W CONS IW1 X=132.855 Y=16.722
 W=3 H=5.4 AZ=339.88 N-T RM03038 ..
R03037 ROOF CONS RF1 X=130.52 Y=14.375 Z=5.4
 W=3 H=1.4 AZ=159.88 TILT=0 ..
B03044 I-W CONS COMMBOARD1 X=130.52 Y=14.375 Z=0
 A=4.199 AZ=159.88 TILT=180 N-T RM02030 ..

RM03038=SPACE S-C=CondType1
 A=5.1  V=27.54  AZ=0   Z=10.8 ..
AW03152 E-W CONS EW1 X=132.855 Y=16.722
 W=1.7 H=5.4 AZ=69.88 S-S YES ..
D03038 Door CONS DR1 X=0.45 Y=0.001
 W=0.799 H=2.099 ..
I03288 I-W CONS IW1 X=132.271 Y=18.318
 W=3 H=5.4 AZ=339.88 N-T RM03039 ..
R03038 ROOF CONS RF1 X=130.039 Y=15.69 Z=5.4
 W=3 H=1.7 AZ=159.88 TILT=0 ..
B03045 I-W CONS COMMBOARD1 X=130.039 Y=15.69 Z=0
 A=5.099 AZ=159.88 TILT=180 N-T RM02031 ..

RM03039=SPACE S-C=CondType1
 A=9  V=48.6  AZ=0   Z=10.8 ..
AW03287 E-W CONS EW1 X=132.271 Y=18.318
 W=3 H=5.4 AZ=69.88 S-S YES ..
WIN03080  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-4
 X=0.95 Y=0
 W=1.099 H=3.849 ..
R03039 ROOF CONS RF1 X=129.454 Y=17.286 Z=5.4
 W=3 H=3 AZ=159.88 TILT=0 ..
B03046 I-W CONS COMMBOARD1 X=129.454 Y=17.286 Z=0
 A=8.999 AZ=159.88 TILT=180 N-T RM02032 ..

RM03040=SPACE S-C=CondType1
 A=7.48  V=40.395  AZ=0   Z=10.8 ..
AW03124 E-W CONS EW1 X=153.962 Y=10.357
 W=3.401 H=5.4 AZ=256.922 S-S YES ..
I03212 I-W CONS IW1 X=153.962 Y=10.357
 W=2.2 H=5.4 AZ=166.922 N-T RM03062 ..
I03135 I-W CONS IW1 X=154.731 Y=7.045
 W=2.201 H=5.4 AZ=166.922 N-T RM03044 ..
I03139 I-W CONS IW1 X=156.874 Y=7.544
 W=3.4 H=5.4 AZ=76.922 N-T RM03044 ..
R03040 ROOF CONS RF1 X=154.824 Y=6.792 Z=5.4
 W=3.401 H=2.2 AZ=159.88 TILT=0 ..
B03047 I-W CONS COMMBOARD1 X=154.349 Y=8.838 Z=0
 A=2.859 AZ=159.88 TILT=180 N-T RM02033 ..
B03050 I-W CONS COMMBOARD1 X=154.824 Y=6.792 Z=0
 A=4.62 AZ=159.88 TILT=180 N-T RM02035 ..

RM03041=SPACE S-C=CondType1
 A=5.163  V=27.881  AZ=0   Z=10.8 ..
AW03170 E-W CONS EW1 X=151.484 Y=21.023
 W=2.95 H=5.4 AZ=256.922 S-S YES ..
I03275 I-W CONS IW1 X=151.484 Y=21.023
 W=1.75 H=5.4 AZ=166.922 N-T RM03043 ..
I03216 I-W CONS IW1 X=152.152 Y=18.149
 W=1.75 H=5.4 AZ=166.922 N-T RM03062 ..
I03172 I-W CONS IW1 X=153.188 Y=21.419
 W=2.95 H=5.4 AZ=256.922 N-T RM03042 ..
R03041 ROOF CONS RF1 X=152.225 Y=17.948 Z=5.4
 W=2.95 H=1.75 AZ=159.88 TILT=0 ..
B03048 I-W CONS COMMBOARD1 X=152.226 Y=17.948 Z=0
 A=5.162 AZ=159.88 TILT=180 N-T RM02034 ..

RM03042=SPACE S-C=CondType1
 A=3.982  V=21.503  AZ=0   Z=10.8 ..
I03168 I-W CONS IW1 X=153.188 Y=21.419
 W=1.35 H=5.4 AZ=166.922 N-T RM03043 ..
I03171 I-W CONS IW1 X=153.856 Y=18.546
 W=1.349 H=5.4 AZ=166.922 N-T RM03062 ..
I03161 I-W CONS IW1 X=154.504 Y=21.725
 W=2.95 H=5.4 AZ=256.922 N-T RM03062 ..
R03042 ROOF CONS RF1 X=153.914 Y=18.39 Z=5.4
 W=2.95 H=1.35 AZ=159.88 TILT=0 ..
B03075 I-W CONS COMMBOARD1 X=153.914 Y=18.39 Z=0
 A=3.982 AZ=159.88 TILT=180 N-T RM02050 ..

RM03043=SPACE S-C=CondType1
 A=4.651  V=25.114  AZ=0   Z=10.8 ..
AW03157 E-W CONS EW1 X=151.144 Y=22.484
 W=1.5 H=5.4 AZ=256.922 S-S YES ..
D03039 Door CONS DR1 X=0.6 Y=0.001
 W=0.799 H=2.099 ..
I03158 I-W CONS IW1 X=151.144 Y=22.484
 W=3.1 H=5.4 AZ=166.922 N-T RM03045 ..
I03042 I-W CONS IW1 X=154.164 Y=23.186
 W=1.5 H=5.4 AZ=256.922 N-T RM03062 ..
R03043 ROOF CONS RF1 X=151.614 Y=20.666 Z=5.4
 W=3.1 H=1.5 AZ=159.88 TILT=0 ..
B03051 I-W CONS COMMBOARD1 X=151.614 Y=20.666 Z=0
 A=4.65 AZ=159.88 TILT=180 N-T RM02036 ..

RM03044=SPACE S-C=CondType3
 A=32.429  V=175.116  AZ=0   Z=10.8 ..
AW03138 E-W CONS EW1 X=154.731 Y=7.045
 W=5.4 H=5.4 AZ=256.922 S-S YES ..
AW03269 E-W CONS EW1 X=155.953 Y=1.785
 W=4.4 H=5.4 AZ=166.922 S-S YES ..
WIN03075  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-36
 X=1.05 Y=0.9
 W=2.299 H=1.499 ..
I03140 I-W CONS IW1 X=156.104 Y=10.855
 W=2.55 H=5.4 AZ=166.922 N-T RM03062 ..
D03029 I-W CONS DR1 X=156.665 Y=0
 A=4.62 N-T RM03062 ..
I03133 I-W CONS IW1 X=159.017 Y=8.041
 W=5.4 H=5.4 AZ=256.922 N-T RM03048 ..
I03134 I-W CONS IW1 X=159.017 Y=8.041
 W=0.35 H=5.4 AZ=166.922 N-T RM03048 ..
I03122 I-W CONS IW1 X=158.589 Y=11.432
 W=3.4 H=5.4 AZ=256.922 N-T RM03048 ..
R03044 ROOF CONS RF1 X=156.138 Y=1.279 Z=5.4
 W=5.4 H=6.006 AZ=159.88 TILT=0 ..
B03005 I-W CONS COMMBOARD1 X=156.205 Y=1.422 Z=0
 A=8.82 AZ=159.88 TILT=180 N-T RM02035 ..
B03049 I-W CONS COMMBOARD1 X=156.138 Y=1.279 Z=0
 A=31.238 AZ=159.88 TILT=180 N-T RM02035 ..
B03056 I-W CONS COMMBOARD1 X=159.032 Y=8.001 Z=0
 A=1.189 AZ=159.88 TILT=180 N-T RM02040 ..

RM03045=SPACE S-C=CondType1
 A=4.185  V=22.601  AZ=0   Z=10.8 ..
AW03274 E-W CONS EW1 X=150.839 Y=23.8
 W=1.35 H=5.4 AZ=256.922 S-S YES ..
D03077 Door CONS DR1 X=0.45 Y=0.001
 W=0.799 H=2.099 ..
I03276 I-W CONS IW1 X=150.839 Y=23.8
 W=3.099 H=5.4 AZ=166.922 N-T RM03046 ..
I03159 I-W CONS IW1 X=153.858 Y=24.501
 W=1.35 H=5.4 AZ=256.922 N-T RM03062 ..
R03045 ROOF CONS RF1 X=151.275 Y=22.127 Z=5.4
 W=3.1 H=1.35 AZ=159.88 TILT=0 ..
B03052 I-W CONS COMMBOARD1 X=151.275 Y=22.128 Z=0
 A=4.185 AZ=159.88 TILT=180 N-T RM02037 ..

RM03046=SPACE S-C=CondType1
 A=9.297  V=50.204  AZ=0   Z=10.8 ..
AW03277 E-W CONS EW1 X=150.161 Y=26.722
 W=3 H=5.4 AZ=256.922 S-S YES ..
WIN03078  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-5
 X=0.95 Y=0
 W=1.099 H=3.849 ..
I03265 I-W CONS IW1 X=150.161 Y=26.722
 W=3.099 H=5.4 AZ=166.922 N-T RM03047 ..
I03106 I-W CONS IW1 X=153.18 Y=27.423
 W=3 H=5.4 AZ=256.922 N-T RM03062 ..
R03046 ROOF CONS RF1 X=150.97 Y=23.443 Z=5.4
 W=3.099 H=3 AZ=159.88 TILT=0 ..
B03053 I-W CONS COMMBOARD1 X=150.97 Y=23.443 Z=0
 A=9.296 AZ=159.88 TILT=180 N-T RM02038 ..

RM03047=SPACE S-C=CondType1
 A=3.411  V=18.417  AZ=0   Z=10.8 ..
AW03107 E-W CONS EW1 X=149.911 Y=27.793
 W=1.1 H=5.4 AZ=256.922 S-S YES ..
D03020 Door CONS DR1 X=0.134 Y=0.001
 W=0.799 H=2.099 ..
I03108 I-W CONS IW1 X=149.911 Y=27.793
 W=3.1 H=5.4 AZ=166.922 N-T RM03062 ..
I03169 I-W CONS IW1 X=152.931 Y=28.495
 W=1.1 H=5.4 AZ=256.922 N-T RM03062 ..
R03047 ROOF CONS RF1 X=150.291 Y=26.365 Z=5.4
 W=3.1 H=1.1 AZ=159.88 TILT=0 ..
B03054 I-W CONS COMMBOARD1 X=150.291 Y=26.365 Z=0
 A=3.41 AZ=159.88 TILT=180 N-T RM02039 ..

RM03048=SPACE S-C=CondType3
 A=37.533  V=202.677  AZ=0   Z=10.8 ..
AW03207 E-W CONS EW1 X=160.239 Y=2.781
 W=4.4 H=5.4 AZ=166.922 S-S YES ..
WIN03045  WINDOW G-T EWIN2 SHADING-SCHEDULE = SC-SASV-36
 X=1.05 Y=0.9
 W=2.299 H=1.499 ..
I03121 I-W CONS IW1 X=158.589 Y=11.432
 W=4.05 H=5.4 AZ=166.922 N-T RM03062 ..
D03025 I-W CONS DR1 X=159.184 Y=0
 A=4.62 N-T RM03062 ..
I03211 I-W CONS IW1 X=162.534 Y=12.349
 W=8.8 H=5.4 AZ=256.922 N-T RM03049 ..
R03048 ROOF CONS RF1 X=160.425 Y=2.274 Z=5.4
 W=8.8 H=4.265 AZ=159.88 TILT=0 ..
B03006 I-W CONS COMMBOARD1 X=160.491 Y=2.418 Z=0
 A=8.82 AZ=159.88 TILT=180 N-T RM02040 ..
B03055 I-W CONS COMMBOARD1 X=160.425 Y=2.274 Z=0
 A=37.532 AZ=159.88 TILT=180 N-T RM02040 ..

RM03049=SPACE S-C=CondType6
 A=421.652  V=2276.92  AZ=0   Z=10.8 ..
AW03213 E-W CONS EW1 X=164.525 Y=3.776
 W=16.6 H=5.4 AZ=166.922 S-S YES ..
I03214 I-W CONS IW1 X=158.777 Y=28.518
 W=16.6 H=5.4 AZ=166.922 N-T RM03062 ..
D03046 I-W CONS DR1 X=175.7 Y=0
 A=3.78 N-T RM03062 ..
D03047 I-W CONS DR1 X=161.517 Y=0
 A=3.78 N-T RM03062 ..
I03268 I-W CONS IW1 X=158.777 Y=28.518
 W=16.6 H=5.4 AZ=256.922 N-T RM03062 ..
D03074 I-W CONS DR1 X=161.924 Y=0
 A=3.78 N-T RM03062 ..
I03252 I-W CONS IW1 X=176.848 Y=24.092
 W=17 H=5.4 AZ=256.922 N-T RM03052 ..
I03256 I-W CONS IW1 X=174.947 Y=32.275
 W=8.4 H=5.4 AZ=256.922 N-T RM03062 ..
R03049 ROOF CONS RF1 X=165.225 Y=1.866 Z=5.4
 W=17 H=24.803 AZ=159.88 TILT=0 ..
B03076 I-W CONS COMMBOARD1 X=165.225 Y=1.866 Z=0
 A=421.652 AZ=159.88 TILT=180 N-T RM02050 ..

RM03050=SPACE S-C=CondType1
 A=4.64  V=25.056  AZ=0   Z=10.8 ..
I03051 I-W CONS IW1 X=178.26 Y=41.873
 W=1.45 H=5.4 AZ=166.922 N-T RM03053 ..
I03205 I-W CONS IW1 X=178.985 Y=38.756
 W=3.2 H=5.4 AZ=76.922 N-T RM03053 ..
I03167 I-W CONS IW1 X=178.985 Y=38.756
 W=1.45 H=5.4 AZ=166.922 N-T RM03062 ..
I03164 I-W CONS IW1 X=180.397 Y=39.084
 W=3.2 H=5.4 AZ=76.922 N-T RM03051 ..
R03050 ROOF CONS RF1 X=179.046 Y=38.589 Z=5.4
 W=3.2 H=1.45 AZ=159.88 TILT=0 ..
B03057 I-W CONS COMMBOARD1 X=179.046 Y=38.589 Z=0
 A=4.64 AZ=159.88 TILT=180 N-T RM02041 ..

RM03051=SPACE S-C=CondType1
 A=4.32  V=23.328  AZ=0   Z=10.8 ..
I03050 I-W CONS IW1 X=179.673 Y=42.201
 W=1.35 H=5.4 AZ=166.922 N-T RM03053 ..
I03165 I-W CONS IW1 X=180.397 Y=39.084
 W=1.35 H=5.4 AZ=166.922 N-T RM03062 ..
I03201 I-W CONS IW1 X=181.712 Y=39.39
 W=3.199 H=5.4 AZ=76.922 N-T RM03053 ..
R03051 ROOF CONS RF1 X=180.454 Y=38.929 Z=5.4
 W=3.2 H=1.35 AZ=159.88 TILT=0 ..
B03077 I-W CONS COMMBOARD1 X=180.454 Y=38.929 Z=0
 A=4.32 AZ=159.88 TILT=180 N-T RM02050 ..

RM03052=SPACE S-C=CondType4
 A=214.204  V=1156.7  AZ=0   Z=10.8 ..
AW03255 E-W CONS EW1 X=180.695 Y=7.533
 W=12.6 H=5.4 AZ=166.922 S-S YES ..
I03263 I-W CONS IW1 X=176.848 Y=24.092
 W=12.6 H=5.4 AZ=166.922 N-T RM03062 ..
D03070 I-W CONS DR1 X=188.935 Y=0
 A=3.78 N-T RM03062 ..
D03071 I-W CONS DR1 X=178.776 Y=0
 A=3.78 N-T RM03062 ..
I03248 I-W CONS IW1 X=192.968 Y=10.384
 W=17 H=5.4 AZ=76.922 N-T RM03054 ..
R03052 ROOF CONS RF1 X=181.226 Y=6.082 Z=5.4
 W=17 H=12.6 AZ=159.88 TILT=0 ..
B03078 I-W CONS COMMBOARD1 X=181.226 Y=6.082 Z=0
 A=214.204 AZ=159.88 TILT=180 N-T RM02050 ..

RM03053=SPACE S-C=CondType4
 A=98.727  V=533.127  AZ=0   Z=10.8 ..
AW03206 E-W CONS EW2 X=189.297 Y=44.745
 W=11.6 H=5.4 AZ=346.921 S-S YES ..
WALL03206  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=11.599 H=4.48 ..
AW03049 E-W CONS EW2 X=177.998 Y=42.12
 W=3.5 H=5.4 AZ=256.922 S-S YES ..
WALL03049  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-40
 X=0 Y=0
 W=3.499 H=4.481 ..
I03166 I-W CONS IW1 X=178.79 Y=38.71
 W=0.2 H=5.4 AZ=166.922 N-T RM03062 ..
I03221 I-W CONS IW1 X=183.477 Y=31.791
 W=7.801 H=5.4 AZ=76.922 N-T RM03062 ..
I03249 I-W CONS IW1 X=183.477 Y=31.791
 W=8.601 H=5.4 AZ=166.922 N-T RM03062 ..
D03060 I-W CONS DR1 X=186.409 Y=0
 A=3.78 N-T RM03062 ..
D03061 I-W CONS DR1 X=192.8 Y=0
 A=3.78 N-T RM03062 ..
I03251 I-W CONS IW1 X=191.855 Y=33.738
 W=11.3 H=5.4 AZ=76.922 N-T RM03055 ..
R03053 ROOF CONS RF1 X=181.942 Y=30.106 Z=5.4
 W=11.6 H=8.511 AZ=159.88 TILT=0 ..
B03079 I-W CONS COMMBOARD1 X=181.942 Y=30.106 Z=0
 A=98.723 AZ=159.88 TILT=180 N-T RM02050 ..

RM03054=SPACE S-C=CondType4
 A=214.198  V=1156.67  AZ=0   Z=10.8 ..
AW03247 E-W CONS EW1 X=192.968 Y=10.384
 W=12.6 H=5.4 AZ=166.922 S-S YES ..
I03246 I-W CONS IW1 X=189.121 Y=26.943
 W=12.6 H=5.4 AZ=166.922 N-T RM03062 ..
D03058 I-W CONS DR1 X=201.49 Y=0
 A=3.78 N-T RM03062 ..
D03059 I-W CONS DR1 X=191.326 Y=0
 A=3.78 N-T RM03062 ..
I03241 I-W CONS IW1 X=205.241 Y=13.236
 W=6.399 H=5.4 AZ=76.922 N-T RM03056 ..
I03223 I-W CONS IW1 X=203.792 Y=19.469
 W=10.601 H=5.4 AZ=76.922 N-T RM03062 ..
R03054 ROOF CONS RF1 X=193.499 Y=8.934 Z=5.4
 W=17 H=12.6 AZ=159.88 TILT=0 ..
B03080 I-W CONS COMMBOARD1 X=193.499 Y=8.934 Z=0
 A=214.198 AZ=159.88 TILT=180 N-T RM02050 ..

RM03055=SPACE S-C=CondType4
 A=92.477  V=499.378  AZ=0   Z=10.8 ..
AW03272 E-W CONS EW1 X=197.352 Y=46.308
 W=0.599 H=5.4 AZ=346.922 S-S YES ..
AW03204 E-W CONS EW1 X=196.768 Y=46.172
 W=0.3 H=5.4 AZ=76.922 S-S YES ..
AW03203 E-W CONS EW2 X=196.7 Y=46.464
 W=7.6 H=5.4 AZ=346.924 S-S YES ..
WALL03203  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=7.599 H=4.481 ..
I03250 I-W CONS IW1 X=191.855 Y=33.738
 W=8.2 H=5.4 AZ=166.922 N-T RM03062 ..
D03062 I-W CONS DR1 X=194.996 Y=0
 A=3.78 N-T RM03062 ..
D03063 I-W CONS DR1 X=200.988 Y=0
 A=3.78 N-T RM03062 ..
I03032 I-W CONS IW1 X=199.842 Y=35.594
 W=3.3 H=5.4 AZ=76.922 N-T RM03062 ..
I03003 I-W CONS IW1 X=199.094 Y=38.808
 W=3.95 H=5.4 AZ=76.922 N-T RM03057 ..
I03004 I-W CONS IW1 X=198.201 Y=42.655
 W=3.75 H=5.4 AZ=76.922 N-T RM03058 ..
R03055 ROOF CONS RF1 X=192.2 Y=32.794 Z=5.4
 W=11.3 H=8.184 AZ=159.88 TILT=0 ..
B03081 I-W CONS COMMBOARD1 X=192.2 Y=32.794 Z=0
 A=92.475 AZ=159.88 TILT=180 N-T RM02050 ..

RM03056=SPACE S-C=CondType4
 A=26.877  V=145.136  AZ=0   Z=10.8 ..
AW03254 E-W CONS EW1 X=205.241 Y=13.236
 W=4.2 H=5.4 AZ=166.922 S-S YES ..
I03224 I-W CONS IW1 X=203.792 Y=19.469
 W=4.2 H=5.4 AZ=166.922 N-T RM03062 ..
D03051 I-W CONS DR1 X=206.152 Y=0
 A=2.94 N-T RM03062 ..
I03240 I-W CONS IW1 X=209.332 Y=14.186
 W=1.5 H=5.4 AZ=76.922 N-T RM03059 ..
I03326 I-W CONS IW1 X=208.992 Y=15.647
 W=4.9 H=5.4 AZ=76.922 N-T RM03061 ..
R03056 ROOF CONS RF1 X=205.418 Y=12.752 Z=5.4
 W=6.399 H=4.2 AZ=159.88 TILT=0 ..
B03060 I-W CONS COMMBOARD1 X=208.4 Y=13.844 Z=0
 A=0.2 AZ=159.88 TILT=180 N-T RM02043 ..
B03088 I-W CONS COMMBOARD1 X=205.376 Y=12.867 Z=0
 A=26.677 AZ=159.88 TILT=180 N-T RM02050 ..

RM03057=SPACE S-C=CondType1
 A=12.638  V=68.245  AZ=0   Z=10.8 ..
I03273 I-W CONS IW1 X=198.201 Y=42.655
 W=3.199 H=5.4 AZ=166.922 N-T RM03058 ..
W03076-1 I-W CONS IWIN1 X=203.889 Y=0
 A=4.235 N-T RM03058 ..
I03236 I-W CONS IW1 X=199.094 Y=38.808
 W=3.2 H=5.4 AZ=166.922 N-T RM03062 ..
D03055 I-W CONS DR1 X=203.791 Y=0
 A=3.15 N-T RM03062 ..
I03245 I-W CONS IW1 X=202.211 Y=39.532
 W=3.95 H=5.4 AZ=76.922 N-T RM03066 ..
R03057 ROOF CONS RF1 X=199.229 Y=38.44 Z=5.4
 W=3.95 H=3.2 AZ=159.88 TILT=0 ..
B03082 I-W CONS COMMBOARD1 X=199.229 Y=38.44 Z=0
 A=12.637 AZ=159.88 TILT=180 N-T RM02050 ..

RM03058=SPACE S-C=CondType1
 A=11.999  V=64.796  AZ=0   Z=10.8 ..
AW03031 E-W CONS EW1 X=200.469 Y=47.033
 W=3.2 H=5.4 AZ=346.922 S-S YES ..
I03033 I-W CONS IW1 X=201.317 Y=43.379
 W=3.75 H=5.4 AZ=76.922 N-T RM03066 ..
R03058 ROOF CONS RF1 X=198.336 Y=42.287 Z=5.4
 W=3.75 H=3.2 AZ=159.88 TILT=0 ..
B03059 I-W CONS COMMBOARD1 X=198.336 Y=42.287 Z=0
 A=11.998 AZ=159.88 TILT=180 N-T RM02042 ..

RM03059=SPACE S-C=CondType1
 A=6.602  V=35.65  AZ=0   Z=10.8 ..
AW03264 E-W CONS EW1 X=209.332 Y=14.186
 W=4.4 H=5.4 AZ=166.922 S-S YES ..
AW03195 E-W CONS EW1 X=213.618 Y=15.181
 W=1.5 H=5.4 AZ=76.922 S-S YES ..
WIN03041  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-41
 X=0.6 Y=0.9
 W=0.799 H=3.849 ..
I03137 I-W CONS IW1 X=208.992 Y=15.647
 W=4.4 H=5.4 AZ=166.922 N-T RM03061 ..
R03059 ROOF CONS RF1 X=209.518 Y=13.679 Z=5.4
 W=4.4 H=1.5 AZ=159.88 TILT=0 ..
B03061 I-W CONS COMMBOARD1 X=209.518 Y=13.679 Z=0
 A=0.881 AZ=159.88 TILT=180 N-T RM02043 ..
B03062 I-W CONS COMMBOARD1 X=209.472 Y=13.874 Z=0
 A=5.719 AZ=159.88 TILT=180 N-T RM02044 ..

RM03060=SPACE S-C=CondType1
 A=1.44  V=7.776  AZ=0   Z=10.8 ..
I03231 I-W CONS IW1 X=203.499 Y=41.062
 W=1.2 H=5.4 AZ=166.922 N-T RM03066 ..
I03235 I-W CONS IW1 X=203.77 Y=39.893
 W=1.2 H=5.4 AZ=76.922 N-T RM03066 ..
I03234 I-W CONS IW1 X=203.77 Y=39.893
 W=1.2 H=5.4 AZ=166.922 N-T RM03062 ..
D03054 I-W CONS DR1 X=207.738 Y=0
 A=1.68 N-T RM03062 ..
I03230 I-W CONS IW1 X=204.939 Y=40.165
 W=1.2 H=5.4 AZ=76.922 N-T RM03063 ..
R03060 ROOF CONS RF1 X=203.821 Y=39.755 Z=5.4
 W=1.2 H=1.2 AZ=159.88 TILT=0 ..
B03083 I-W CONS COMMBOARD1 X=203.821 Y=39.755 Z=0
 A=1.44 AZ=159.88 TILT=180 N-T RM02050 ..

RM03061=SPACE S-C=CondType3
 A=32.119  V=173.441  AZ=0   Z=10.8 ..
AW03136 E-W CONS EW1 X=213.279 Y=16.642
 W=7.3 H=5.4 AZ=76.922 S-S YES ..
WIN03028  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-42
 X=5.025 Y=0.9
 W=1.149 H=2.199 ..
I03196 I-W CONS IW1 X=207.341 Y=22.757
 W=4.399 H=5.4 AZ=166.922 N-T RM03065 ..
I03120 I-W CONS IW1 X=207.883 Y=20.42
 W=2.399 H=5.4 AZ=76.922 N-T RM03062 ..
D03024 I-W CONS DR1 X=207.631 Y=0
 A=4.62 N-T RM03062 ..
R03061 ROOF CONS RF1 X=209.178 Y=15.14 Z=5.4
 W=7.3 H=4.4 AZ=159.88 TILT=0 ..
B03012 I-W CONS COMMBOARD1 X=209.244 Y=15.283 Z=0
 A=8.82 AZ=159.88 TILT=180 N-T RM02045 ..
B03063 I-W CONS COMMBOARD1 X=209.178 Y=15.14 Z=0
 A=31.238 AZ=159.88 TILT=180 N-T RM02045 ..
B03066 I-W CONS COMMBOARD1 X=207.571 Y=22.056 Z=0
 A=0.879 AZ=159.88 TILT=180 N-T RM02046 ..

RM03062=SPACE S-C=CondType4
 A=648.387  V=3501.29  AZ=0   Z=10.8 ..
AW03071 E-W CONS EW2 X=178.79 Y=38.71
 W=5 H=5.4 AZ=346.922 S-S YES ..
WALL03071  WINDOW G-T EWIN4 SHADING-SCHEDULE = SC-SASV-5
 X=0 Y=0
 W=4.999 H=4.481 ..
AW03202 E-W CONS EW1 X=173.92 Y=37.579
 W=3.2 H=5.4 AZ=76.922 S-S YES ..
AW03278 E-W CONS EW1 X=173.195 Y=40.696
 W=25.6 H=5.4 AZ=346.922 S-S YES ..
AW03279 E-W CONS EW1 X=148.259 Y=34.904
 W=7.3 H=5.4 AZ=256.922 S-S YES ..
AW03215 E-W CONS EW2 X=152.152 Y=18.149
 W=7.999 H=5.4 AZ=256.922 S-S YES ..
WALL03215  WINDOW G-T EWIN1 SHADING-SCHEDULE = SC-SASV-26
 X=0 Y=0
 W=7.998 H=4.481 ..
AW03238 E-W CONS EW1 X=208.413 Y=37.584
 W=3.3 H=5.4 AZ=76.922 S-S YES ..
I03232 I-W CONS IW1 X=206.011 Y=40.414
 W=1.7 H=5.4 AZ=166.922 N-T RM03067 ..
D03053 I-W CONS DR1 X=210.137 Y=0
 A=2.1 N-T RM03067 ..
I03225 I-W CONS IW1 X=204.939 Y=40.165
 W=1.1 H=5.4 AZ=166.922 N-T RM03063 ..
D03052 I-W CONS DR1 X=209.088 Y=0
 A=1.68 N-T RM03063 ..
I03237 I-W CONS IW1 X=202.211 Y=39.532
 W=1.6 H=5.4 AZ=166.922 N-T RM03066 ..
D03056 I-W CONS DR1 X=206.239 Y=0
 A=2.1 N-T RM03066 ..
I03262 I-W CONS IW1 X=207.341 Y=22.757
 W=8.201 H=5.4 AZ=76.922 N-T RM03065 ..
D03069 I-W CONS DR1 X=207.335 Y=0
 A=4.62 N-T RM03065 ..
I03242 I-W CONS IW1 X=205.485 Y=30.745
 W=5.999 H=5.4 AZ=76.922 N-T RM03064 ..
D03057 I-W CONS DR1 X=206.681 Y=0
 A=3.15 N-T RM03064 ..
I03244 I-W CONS IW1 X=202.959 Y=36.317
 W=1.2 H=5.4 AZ=166.922 N-T RM03062 ..
I03239 I-W CONS IW1 X=202.959 Y=36.317
 W=1.1 H=5.4 AZ=76.922 N-T RM03062 ..
I03243 I-W CONS IW1 X=204.128 Y=36.589
 W=3.4 H=5.4 AZ=166.922 N-T RM03064 ..
I03162 I-W CONS IW1 X=207.439 Y=37.359
 W=1 H=5.4 AZ=166.922 N-T RM03064 ..
R03062 ROOF CONS RF1 X=157.092 Y=1.813 Z=5.4
 W=25.6 H=25.327 AZ=159.88 TILT=0 ..
B03058 I-W CONS COMMBOARD1 X=179.137 Y=38.199 Z=0
 A=0.58 AZ=159.88 TILT=180 N-T RM02041 ..
B03065 I-W CONS COMMBOARD1 X=206.454 Y=22.221 Z=0
 A=2.551 AZ=159.88 TILT=180 N-T RM02046 ..
B03089 I-W CONS COMMBOARD1 X=157.092 Y=1.813 Z=0
 A=645.25 AZ=159.88 TILT=180 N-T RM02050 ..

RM03063=SPACE S-C=CondType1
 A=1.32  V=7.13  AZ=0   Z=10.8 ..
I03229 I-W CONS IW1 X=204.667 Y=41.334
 W=1.1 H=5.4 AZ=166.922 N-T RM03067 ..
I03233 I-W CONS IW1 X=206.011 Y=40.414
 W=1.2 H=5.4 AZ=76.922 N-T RM03067 ..
R03063 ROOF CONS RF1 X=204.986 Y=40.038 Z=5.4
 W=1.2 H=1.1 AZ=159.88 TILT=0 ..
B03084 I-W CONS COMMBOARD1 X=204.986 Y=40.038 Z=0
 A=1.32 AZ=159.88 TILT=180 N-T RM02050 ..

RM03064=SPACE S-C=CondType6
 A=26.398  V=142.548  AZ=0   Z=10.8 ..
AW03270 E-W CONS EW1 X=209.771 Y=31.74
 W=6 H=5.4 AZ=76.922 S-S YES ..
I03253 I-W CONS IW1 X=205.485 Y=30.745
 W=3.4 H=5.4 AZ=166.922 N-T RM03065 ..
I03163 I-W CONS IW1 X=208.796 Y=31.514
 W=1.001 H=5.4 AZ=166.922 N-T RM03065 ..
R03064 ROOF CONS RF1 X=205.671 Y=30.238 Z=5.4
 W=6 H=4.4 AZ=159.88 TILT=0 ..
B03085 I-W CONS COMMBOARD1 X=205.671 Y=30.238 Z=0
 A=26.398 AZ=159.88 TILT=180 N-T RM02050 ..

RM03065=SPACE S-C=CondType3
 A=36.08  V=194.83  AZ=0   Z=10.8 ..
AW03267 E-W CONS EW1 X=211.626 Y=23.753
 W=8.2 H=5.4 AZ=76.922 S-S YES ..
WIN03073  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-42
 X=6.125 Y=0.9
 W=1.149 H=2.199 ..
R03065 ROOF CONS RF1 X=207.526 Y=22.251 Z=5.4
 W=8.201 H=4.4 AZ=159.88 TILT=0 ..
B03011 I-W CONS COMMBOARD1 X=206.383 Y=27.456 Z=0
 A=11.025 AZ=159.88 TILT=180 N-T RM02046 ..
B03064 I-W CONS COMMBOARD1 X=207.526 Y=22.251 Z=0
 A=36.078 AZ=159.88 TILT=180 N-T RM02046 ..

RM03066=SPACE S-C=CondType1
 A=20.123  V=108.663  AZ=0   Z=10.8 ..
AW03271 E-W CONS EW1 X=203.197 Y=47.665
 W=2.8 H=5.4 AZ=346.922 S-S YES ..
I03226 I-W CONS IW1 X=204.667 Y=41.334
 W=6.5 H=5.4 AZ=76.922 N-T RM03067 ..
R03066 ROOF CONS RF1 X=202.279 Y=39.347 Z=5.4
 W=6.5 H=3.096 AZ=159.88 TILT=0 ..
B03086 I-W CONS COMMBOARD1 X=202.279 Y=39.347 Z=0
 A=20.123 AZ=159.88 TILT=180 N-T RM02050 ..

RM03067=SPACE S-C=CondType1
 A=20.241  V=109.303  AZ=0   Z=10.8 ..
AW03227 E-W CONS EW1 X=205.924 Y=48.299
 W=2.8 H=5.4 AZ=346.922 S-S YES ..
AW03228 E-W CONS EW1 X=207.667 Y=40.799
 W=7.7 H=5.4 AZ=76.922 S-S YES ..
R03067 ROOF CONS RF1 X=205.195 Y=39.894 Z=5.4
 W=7.7 H=2.629 AZ=159.88 TILT=0 ..
B03087 I-W CONS COMMBOARD1 X=205.195 Y=39.894 Z=0
 A=20.241 AZ=159.88 TILT=180 N-T RM02050 ..

RM03068=SPACE S-C=CondType1
 A=0.33  V=1.782  AZ=0   Z=10.8 ..
AW03327 E-W CONS EW2 X=64.328 Y=9.296
 W=1.1 H=5.4 AZ=69.88 S-S YES ..
WALL03327  WINDOW G-T EWIN3 SHADING-SCHEDULE = SC-SASV-4
 X=0 Y=0
 W=1.099 H=4.484 ..
R03068 ROOF CONS RF1 X=64.046 Y=9.193 Z=5.4
 W=1.1 H=0.3 AZ=159.88 TILT=0 ..
B03072 I-W CONS COMMBOARD1 X=63.805 Y=9.85 Z=0
 A=0.12 AZ=159.88 TILT=180 N-T RM02048 ..
B03092 E-W CONS ABOARD1 X=64.046 Y=9.193 Z=0
 W=0.7 H=0.3 AZ=69.88 TILT=180 ..

RM03069=SPACE S-C=CondType1
 A=1.95  V=10.53  AZ=0   Z=10.8 ..
R03069 ROOF CONS RF1 X=90.823 Y=4.998 Z=5.4
 W=1.5 H=1.3 AZ=159.88 TILT=0 ..
B03038 I-W CONS COMMBOARD1 X=90.823 Y=4.998 Z=0
 A=1.95 AZ=159.88 TILT=180 N-T RM02024 ..


 $ ½¨ÖþÎïÖðÊ±¸ººÉ±¨¸æÊé 
HRSCHBD=SCHEDULE  THRU DEC 31 (ALL) (1,24) VALUES=(1)   ..
DBTBDLD REPORT-BLOCK  
      VARIABLE-TYPE= BUILDING
      VARIABLE-LIST=(1,2,3,4,5,6,7,8,
                     9,10,11,12,13,14,15,16,
                     17,18,19,20,21,22,23,24,
                     25,26,27,28,29,30,31,32,
                     33,34,35,36,37,38,39,40,
                     41) .. 
HRBDLD HOURLY-REPORT REPORT-SCHEDULE=HRSCHBD R-B=(DBTBDLD)..


END  ..
COMPUTE LOADS  .. 

INPUT SYSTEMS
INPUT-UNITS METRIC
OUTPUT-UNITS METRIC  ..

ABORT ERRORS   ..
DIAGNOSTIC WARNINGS   ..


$Cooling Schedule:
  CoolSCH1  SCHEDULE 
  THRU DEC  31
     (WD) (1,24) TEMP = 
       (37, 37, 37, 37, 37, 37, 28, 26, 
        26, 26, 26, 26, 26, 26, 26, 26, 
        26, 26, 37, 37, 37, 37, 37, 37)
     (WEH) (1,24) TEMP = 
       (37)
   .. 
  CoolSCH2  SCHEDULE 
  THRU DEC  31
     (ALL) (1,24) TEMP =        (25)
   .. 
  CoolSCH3  SCHEDULE 
  THRU DEC  31
     (WD) (1,24) TEMP = 
       (37, 37, 37, 37, 37, 37, 28, 26, 
        26, 26, 26, 26, 26, 26, 26, 26, 
        26, 26, 37, 37, 37, 37, 37, 37)
     (WEH) (1,24) TEMP = 
       (37)
   .. 
  CoolSCH4  SCHEDULE 
  THRU DEC  31
     (WD) (1,24) TEMP = 
       (37, 37, 37, 37, 37, 37, 28, 26, 
        26, 26, 26, 26, 26, 26, 26, 26, 
        26, 26, 37, 37, 37, 37, 37, 37)
     (WEH) (1,24) TEMP = 
       (37)
   .. 
  CoolSCH5  SCHEDULE 
  THRU DEC  31
     (ALL) (1,24) TEMP =        (26)
   .. 
  CoolSCH6  SCHEDULE 
  THRU DEC  31
     (WD) (1,24) TEMP = 
       (37, 37, 37, 37, 37, 37, 28, 26, 
        26, 26, 26, 26, 26, 26, 26, 26, 
        26, 26, 37, 37, 37, 37, 37, 37)
     (WEH) (1,24) TEMP = 
       (37)
   .. 
$Heating Schedule:
  HeatSCH1  SCHEDULE 
  THRU DEC  31
     (WD) (1,24) TEMP = 
       (5, 5, 5, 5, 5, 12, 18, 20, 
        20, 20, 20, 20, 20, 20, 20, 20, 
        20, 20, 18, 12, 5, 5, 5, 5)
     (WEH) (1,24) TEMP = 
       (5)
   .. 
  HeatSCH2  SCHEDULE 
  THRU DEC  31
     (ALL) (1,24) TEMP =        (22)
   .. 
  HeatSCH3  SCHEDULE 
  THRU DEC  31
     (WD) (1,24) TEMP = 
       (5, 5, 5, 5, 5, 12, 18, 20, 
        20, 20, 20, 20, 20, 20, 20, 20, 
        20, 20, 18, 12, 5, 5, 5, 5)
     (WEH) (1,24) TEMP = 
       (5)
   .. 
  HeatSCH4  SCHEDULE 
  THRU DEC  31
     (WD) (1,24) TEMP = 
       (5, 5, 5, 5, 5, 12, 18, 20, 
        20, 20, 20, 20, 20, 20, 20, 20, 
        20, 20, 18, 12, 5, 5, 5, 5)
     (WEH) (1,24) TEMP = 
       (5)
   .. 
  HeatSCH5  SCHEDULE 
  THRU DEC  31
     (ALL) (1,24) TEMP =        (16)
   .. 
  HeatSCH6  SCHEDULE 
  THRU DEC  31
     (WD) (1,24) TEMP = 
       (5, 5, 5, 5, 5, 12, 18, 20, 
        20, 20, 20, 20, 20, 20, 20, 20, 
        20, 20, 18, 12, 5, 5, 5, 5)
     (WEH) (1,24) TEMP = 
       (5)
   .. 
$Zone Type:
ZoneType2-T=Z-C
 DESIGN-HEAT-T=22 DESIGN-COOL-T=25
 HEAT-TEMP-SCH=HeatSCH2 COOL-TEMP-SCH=CoolSCH2 ..
ZoneType3-T=Z-C
 DESIGN-HEAT-T=20 DESIGN-COOL-T=26
 HEAT-TEMP-SCH=HeatSCH3 COOL-TEMP-SCH=CoolSCH3 ..
ZoneType4-T=Z-C
 DESIGN-HEAT-T=20 DESIGN-COOL-T=26
 HEAT-TEMP-SCH=HeatSCH4 COOL-TEMP-SCH=CoolSCH4 ..
ZoneType6-T=Z-C
 DESIGN-HEAT-T=20 DESIGN-COOL-T=26
 HEAT-TEMP-SCH=HeatSCH6 COOL-TEMP-SCH=CoolSCH6 ..

RM01001  ZONE ZONE-TYPE UNCONDITIONED ..
RM01002  ZONE ZONE-TYPE UNCONDITIONED ..
RM01003  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType2-T OA-CFM/PER=30 ..
RM01004  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType3-T OA-CFM/PER=30 ..
RM01005  ZONE ZONE-TYPE UNCONDITIONED ..
RM01006  ZONE ZONE-TYPE UNCONDITIONED ..
RM01007  ZONE ZONE-TYPE UNCONDITIONED ..
RM01008  ZONE ZONE-TYPE UNCONDITIONED ..
RM01009  ZONE ZONE-TYPE UNCONDITIONED ..
RM01010  ZONE ZONE-TYPE UNCONDITIONED ..
RM01011  ZONE ZONE-TYPE UNCONDITIONED ..
RM01012  ZONE ZONE-TYPE UNCONDITIONED ..
RM01013  ZONE ZONE-TYPE UNCONDITIONED ..
RM01014  ZONE ZONE-TYPE UNCONDITIONED ..
RM01015  ZONE ZONE-TYPE UNCONDITIONED ..
RM01016  ZONE ZONE-TYPE UNCONDITIONED ..
RM01017  ZONE ZONE-TYPE UNCONDITIONED ..
RM01018  ZONE ZONE-TYPE UNCONDITIONED ..
RM01019  ZONE ZONE-TYPE UNCONDITIONED ..
RM01020  ZONE ZONE-TYPE UNCONDITIONED ..
RM01021  ZONE ZONE-TYPE UNCONDITIONED ..
RM01022  ZONE ZONE-TYPE UNCONDITIONED ..
RM01023  ZONE ZONE-TYPE UNCONDITIONED ..
RM01024  ZONE ZONE-TYPE UNCONDITIONED ..
RM01025  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType4-T OA-CFM/PER=30 ..
RM01026  ZONE ZONE-TYPE UNCONDITIONED ..
RM01027  ZONE ZONE-TYPE UNCONDITIONED ..
RM01028  ZONE ZONE-TYPE UNCONDITIONED ..
RM01029  ZONE ZONE-TYPE UNCONDITIONED ..
RM01030  ZONE ZONE-TYPE UNCONDITIONED ..
RM01031  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType4-T OA-CFM/PER=30 ..
RM01032  ZONE ZONE-TYPE UNCONDITIONED ..
RM01033  ZONE ZONE-TYPE UNCONDITIONED ..
RM01034  ZONE ZONE-TYPE UNCONDITIONED ..
RM01035  ZONE ZONE-TYPE UNCONDITIONED ..
RM01036  ZONE ZONE-TYPE UNCONDITIONED ..
RM01037  ZONE ZONE-TYPE UNCONDITIONED ..
RM01038  ZONE ZONE-TYPE UNCONDITIONED ..
RM01039  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType4-T OA-CFM/PER=30 ..
RM01040  ZONE ZONE-TYPE UNCONDITIONED ..
RM01041  ZONE ZONE-TYPE UNCONDITIONED ..
RM01042  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType4-T OA-CFM/PER=30 ..
RM01043  ZONE ZONE-TYPE UNCONDITIONED ..
RM01044  ZONE ZONE-TYPE UNCONDITIONED ..
RM01045  ZONE ZONE-TYPE UNCONDITIONED ..
RM01046  ZONE ZONE-TYPE UNCONDITIONED ..
RM01047  ZONE ZONE-TYPE UNCONDITIONED ..
RM01048  ZONE ZONE-TYPE UNCONDITIONED ..
RM01049  ZONE ZONE-TYPE UNCONDITIONED ..
RM01050  ZONE ZONE-TYPE UNCONDITIONED ..
RM01051  ZONE ZONE-TYPE UNCONDITIONED ..
RM01052  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType2-T OA-CFM/PER=30 ..
RM01053  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType2-T OA-CFM/PER=30 ..
RM02001  ZONE ZONE-TYPE UNCONDITIONED ..
RM02002  ZONE ZONE-TYPE UNCONDITIONED ..
RM02003  ZONE ZONE-TYPE UNCONDITIONED ..
RM02004  ZONE ZONE-TYPE UNCONDITIONED ..
RM02005  ZONE ZONE-TYPE UNCONDITIONED ..
RM02006  ZONE ZONE-TYPE UNCONDITIONED ..
RM02007  ZONE ZONE-TYPE UNCONDITIONED ..
RM02008  ZONE ZONE-TYPE UNCONDITIONED ..
RM02009  ZONE ZONE-TYPE UNCONDITIONED ..
RM02010  ZONE ZONE-TYPE UNCONDITIONED ..
RM02011  ZONE ZONE-TYPE UNCONDITIONED ..
RM02012  ZONE ZONE-TYPE UNCONDITIONED ..
RM02013  ZONE ZONE-TYPE UNCONDITIONED ..
RM02014  ZONE ZONE-TYPE UNCONDITIONED ..
RM02015  ZONE ZONE-TYPE UNCONDITIONED ..
RM02016  ZONE ZONE-TYPE UNCONDITIONED ..
RM02017  ZONE ZONE-TYPE UNCONDITIONED ..
RM02018  ZONE ZONE-TYPE UNCONDITIONED ..
RM02019  ZONE ZONE-TYPE UNCONDITIONED ..
RM02020  ZONE ZONE-TYPE UNCONDITIONED ..
RM02021  ZONE ZONE-TYPE UNCONDITIONED ..
RM02022  ZONE ZONE-TYPE UNCONDITIONED ..
RM02023  ZONE ZONE-TYPE UNCONDITIONED ..
RM02024  ZONE ZONE-TYPE UNCONDITIONED ..
RM02025  ZONE ZONE-TYPE UNCONDITIONED ..
RM02026  ZONE ZONE-TYPE UNCONDITIONED ..
RM02027  ZONE ZONE-TYPE UNCONDITIONED ..
RM02028  ZONE ZONE-TYPE UNCONDITIONED ..
RM02029  ZONE ZONE-TYPE UNCONDITIONED ..
RM02030  ZONE ZONE-TYPE UNCONDITIONED ..
RM02031  ZONE ZONE-TYPE UNCONDITIONED ..
RM02032  ZONE ZONE-TYPE UNCONDITIONED ..
RM02033  ZONE ZONE-TYPE UNCONDITIONED ..
RM02034  ZONE ZONE-TYPE UNCONDITIONED ..
RM02035  ZONE ZONE-TYPE UNCONDITIONED ..
RM02036  ZONE ZONE-TYPE UNCONDITIONED ..
RM02037  ZONE ZONE-TYPE UNCONDITIONED ..
RM02038  ZONE ZONE-TYPE UNCONDITIONED ..
RM02039  ZONE ZONE-TYPE UNCONDITIONED ..
RM02040  ZONE ZONE-TYPE UNCONDITIONED ..
RM02041  ZONE ZONE-TYPE UNCONDITIONED ..
RM02042  ZONE ZONE-TYPE UNCONDITIONED ..
RM02043  ZONE ZONE-TYPE UNCONDITIONED ..
RM02044  ZONE ZONE-TYPE UNCONDITIONED ..
RM02045  ZONE ZONE-TYPE UNCONDITIONED ..
RM02046  ZONE ZONE-TYPE UNCONDITIONED ..
RM02047  ZONE ZONE-TYPE UNCONDITIONED ..
RM02048  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType2-T OA-CFM/PER=30 ..
RM02049  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType4-T OA-CFM/PER=30 ..
RM02050  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType4-T OA-CFM/PER=30 ..
RM02051  ZONE ZONE-TYPE UNCONDITIONED ..
RM02052  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType2-T OA-CFM/PER=30 ..
RM03001  ZONE ZONE-TYPE UNCONDITIONED ..
RM03002  ZONE ZONE-TYPE UNCONDITIONED ..
RM03003  ZONE ZONE-TYPE UNCONDITIONED ..
RM03004  ZONE ZONE-TYPE UNCONDITIONED ..
RM03005  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType2-T OA-CFM/PER=30 ..
RM03006  ZONE ZONE-TYPE UNCONDITIONED ..
RM03007  ZONE ZONE-TYPE UNCONDITIONED ..
RM03008  ZONE ZONE-TYPE UNCONDITIONED ..
RM03009  ZONE ZONE-TYPE UNCONDITIONED ..
RM03010  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType2-T OA-CFM/PER=30 ..
RM03011  ZONE ZONE-TYPE UNCONDITIONED ..
RM03012  ZONE ZONE-TYPE UNCONDITIONED ..
RM03013  ZONE ZONE-TYPE UNCONDITIONED ..
RM03014  ZONE ZONE-TYPE UNCONDITIONED ..
RM03015  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType2-T OA-CFM/PER=30 ..
RM03016  ZONE ZONE-TYPE UNCONDITIONED ..
RM03017  ZONE ZONE-TYPE UNCONDITIONED ..
RM03018  ZONE ZONE-TYPE UNCONDITIONED ..
RM03019  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType3-T OA-CFM/PER=30 ..
RM03020  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType2-T OA-CFM/PER=30 ..
RM03021  ZONE ZONE-TYPE UNCONDITIONED ..
RM03022  ZONE ZONE-TYPE UNCONDITIONED ..
RM03023  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType3-T OA-CFM/PER=30 ..
RM03024  ZONE ZONE-TYPE UNCONDITIONED ..
RM03025  ZONE ZONE-TYPE UNCONDITIONED ..
RM03026  ZONE ZONE-TYPE UNCONDITIONED ..
RM03027  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType3-T OA-CFM/PER=30 ..
RM03028  ZONE ZONE-TYPE UNCONDITIONED ..
RM03029  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType4-T OA-CFM/PER=30 ..
RM03030  ZONE ZONE-TYPE UNCONDITIONED ..
RM03031  ZONE ZONE-TYPE UNCONDITIONED ..
RM03032  ZONE ZONE-TYPE UNCONDITIONED ..
RM03033  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType3-T OA-CFM/PER=30 ..
RM03034  ZONE ZONE-TYPE UNCONDITIONED ..
RM03035  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType3-T OA-CFM/PER=30 ..
RM03036  ZONE ZONE-TYPE UNCONDITIONED ..
RM03037  ZONE ZONE-TYPE UNCONDITIONED ..
RM03038  ZONE ZONE-TYPE UNCONDITIONED ..
RM03039  ZONE ZONE-TYPE UNCONDITIONED ..
RM03040  ZONE ZONE-TYPE UNCONDITIONED ..
RM03041  ZONE ZONE-TYPE UNCONDITIONED ..
RM03042  ZONE ZONE-TYPE UNCONDITIONED ..
RM03043  ZONE ZONE-TYPE UNCONDITIONED ..
RM03044  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType3-T OA-CFM/PER=30 ..
RM03045  ZONE ZONE-TYPE UNCONDITIONED ..
RM03046  ZONE ZONE-TYPE UNCONDITIONED ..
RM03047  ZONE ZONE-TYPE UNCONDITIONED ..
RM03048  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType3-T OA-CFM/PER=30 ..
RM03049  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType6-T OA-CFM/PER=30 ..
RM03050  ZONE ZONE-TYPE UNCONDITIONED ..
RM03051  ZONE ZONE-TYPE UNCONDITIONED ..
RM03052  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType4-T OA-CFM/PER=30 ..
RM03053  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType4-T OA-CFM/PER=30 ..
RM03054  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType4-T OA-CFM/PER=30 ..
RM03055  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType4-T OA-CFM/PER=30 ..
RM03056  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType4-T OA-CFM/PER=30 ..
RM03057  ZONE ZONE-TYPE UNCONDITIONED ..
RM03058  ZONE ZONE-TYPE UNCONDITIONED ..
RM03059  ZONE ZONE-TYPE UNCONDITIONED ..
RM03060  ZONE ZONE-TYPE UNCONDITIONED ..
RM03061  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType3-T OA-CFM/PER=30 ..
RM03062  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType4-T OA-CFM/PER=30 ..
RM03063  ZONE ZONE-TYPE UNCONDITIONED ..
RM03064  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType6-T OA-CFM/PER=30 ..
RM03065  ZONE ZONE-TYPE CONDITIONED
 Z-C ZoneType3-T OA-CFM/PER=30 ..
RM03066  ZONE ZONE-TYPE UNCONDITIONED ..
RM03067  ZONE ZONE-TYPE UNCONDITIONED ..
RM03068  ZONE ZONE-TYPE UNCONDITIONED ..
RM03069  ZONE ZONE-TYPE UNCONDITIONED ..
$ HeatCoolOSCH  : 
  CoolOSSCH1  SCHEDULE 
  THRU DEC  31
     (WD) (1,24) VALUES = 
       (0, 0, 0, 0, 0, 1, 1, 1, 
        1, 1, 1, 1, 1, 1, 1, 1, 
        1, 0, 0, 0, 0, 0, 0, 0)
     (WEH) (1,24) VALUES = 
       (0)
   .. 
  CoolOSSCH2  SCHEDULE 
  THRU DEC  31
     (ALL) (1,24) VALUES =        (1)
   .. 
  CoolOSSCH3  SCHEDULE 
  THRU DEC  31
     (ALL) (1,24) VALUES =        (1)
   .. 
  CoolOSSCH4  SCHEDULE 
  THRU DEC  31
     (ALL) (1,24) VALUES =        (1)
   .. 
  CoolOSSCH5  SCHEDULE 
  THRU DEC  31
     (ALL) (1,24) VALUES =        (1)
   .. 
  CoolOSSCH6  SCHEDULE 
  THRU DEC  31
     (ALL) (1,24) VALUES =        (1)
   .. 
  CoolOSSCH7  SCHEDULE 
  THRU DEC  31
     (ALL) (1,24) VALUES =        (1)
   .. 
  CoolOSSCH8  SCHEDULE 
  THRU DEC  31
     (ALL) (1,24) VALUES =        (1)
   .. 

  HeatOSSCH1  SCHEDULE 
  THRU DEC  31
     (WD) (1,24) VALUES = 
       (0, 0, 0, 0, 0, 1, 1, 1, 
        1, 1, 1, 1, 1, 1, 1, 1, 
        1, 0, 0, 0, 0, 0, 0, 0)
     (WEH) (1,24) VALUES = 
       (0)
   .. 
  HeatOSSCH2  SCHEDULE 
  THRU DEC  31
     (ALL) (1,24) VALUES =        (1)
   .. 
  HeatOSSCH3  SCHEDULE 
  THRU DEC  31
     (ALL) (1,24) VALUES =        (1)
   .. 
  HeatOSSCH4  SCHEDULE 
  THRU DEC  31
