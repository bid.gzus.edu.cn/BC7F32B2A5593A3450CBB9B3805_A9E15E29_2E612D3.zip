             ,RM02031,RM02033,RM02043,RM02051,RM02044,RM02045
             ,RM02047,RM02041,RM02046,RM02042,RM03007,RM03008
             ,RM03006,RM03002,RM03009,RM03003,RM03004,RM03001
             ,RM03018,RM03014,RM03011,RM03017,RM03012,RM03016
             ,RM03019,RM03021,RM03013,RM03023,RM03024,RM03022
             ,RM03028,RM03031,RM03025,RM03032,RM03033,RM03026
             ,RM03030,RM03027,RM03045,RM03041,RM03046,RM03038
             ,RM03039,RM03035,RM03043,RM03036,RM03042,RM03037
             ,RM03044,RM03034,RM03040,RM03050,RM03048,RM03051
             ,RM03057,RM03058,RM03047,RM03069,RM03066,RM03061
             ,RM03059,RM03063,RM03060,RM03065,RM03067,RM03068) ..

PLT-P PLANT-ASSIGNMENT SYSTEM-NAMES
 (sys1,sys2) ..
SYSTEMS-REPORT S (SS-A,SS-B,SS-C,SS-D,SS-E,SS-F,SS-G) ..



 $ ÏµÍ³ÖðÊ±¸ººÉ±¨¸æÊé 
HRSYSSCH=SCHEDULE  THRU DEC 31 (ALL) (1,24) VALUES=(1)   ..
DBSS1  REPORT-BLOCK  VARIABLE-TYPE=sys1
          VARIABLE-LIST=(7,8,48) ..
HRPsys1  HOURLY-REPORT  REPORT-SCHEDULE=HRSYSSCH R-B=(DBSS1) ..

DBSS2  REPORT-BLOCK  VARIABLE-TYPE=sys2
          VARIABLE-LIST=(6,7,48) ..
HRPsys2  HOURLY-REPORT  REPORT-SCHEDULE=HRSYSSCH R-B=(DBSS2) ..


END ..
COMPUTE SYSTEMS ..

INPUT PLANT  OUTPUT-UNITS METRIC ..
TITLE  LINE-1 *PLANT RUN1* ..
PLT-P  PLANT-ASSIGNMENT ..
CLG P-E TYPE HERM-CENT-CHLR SIZE -999 I-N 1 ..
HLG P-E TYPE HW-BOILER SIZE -999 I-N 1 ..
ENERGY-RESOURCE RESOURCE NATURAL-GAS  ..
PART-LOAD-RATIO TYPE HERM-CENT-CHLR E-I-R 0.33  ..
ENERGY-RESOURCE RESOURCE ELECTRICITY ..

PLANT-REPORT 
S (ALL-SUMMARY) ..
HrSchHv1 = SCHEDULE
  THRU DEC 31 (ALL) (1,24) VALUES=(1)   .. 
  HrDbHv1 = REPORT-BLOCK  
  V-T = END-USE
  V-L = (1,2,3,5,6,7,8,9,15,16)  ..
  HrRepHv1 = HOURLY-REPORT  
  REPORT-SCHEDULE=HrSchHv1
  R-B=(HrDbHv1) ..

END  ..
COMPUTE PLANT  ..

STOP  ..
