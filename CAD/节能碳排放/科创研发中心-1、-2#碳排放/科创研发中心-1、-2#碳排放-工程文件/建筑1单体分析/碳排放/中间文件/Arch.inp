RM03069  ZONE ZONE-TYPE UNCONDITIONED ..
$ HeatCoolOSCH  : 
  CoolOSSCH1  SCHEDULE 
  THRU DEC  31
     (ALL) (1,24) VALUES =        (0)
   .. 
  CoolOSSCH2  SCHEDULE 
  THRU DEC  31
     (ALL) (1,24) VALUES =        (1)
   .. 
  CoolOSSCH3  SCHEDULE 
  THRU DEC  31
     (WD) (1,24) VALUES = 
       (0, 0, 0, 0, 0, 0, 1, 1, 
        1, 1, 1, 1, 1, 1, 1, 1, 
        1, 1, 0, 0, 0, 0, 0, 0)
     (WEH) (1,24) VALUES = 
       (0)
   .. 
  CoolOSSCH4  SCHEDULE 
  THRU DEC  31
     (WD) (1,24) VALUES = 
       (0, 0, 0, 0, 0, 0, 1, 1, 
        1, 1, 1, 1, 1, 1, 1, 1, 
        1, 1, 0, 0, 0, 0, 0, 0)
     (WEH) (1,24) VALUES = 
       (0)
   .. 
  CoolOSSCH5  SCHEDULE 
  THRU DEC  31
     (WD) (1,24) VALUES = 
       (0, 0, 0, 0, 0, 0, 1, 1, 
        1, 1, 1, 1, 1, 1, 1, 1, 
        1, 1, 0, 0, 0, 0, 0, 0)
     (WEH) (1,24) VALUES = 
       (0)
   .. 

  HeatOSSCH1  SCHEDULE 
  THRU DEC  31
     (ALL) (1,24) VALUES =        (0)
   .. 
  HeatOSSCH2  SCHEDULE 
  THRU DEC  31
     (ALL) (1,24) VALUES =        (1)
   .. 
  HeatOSSCH3  SCHEDULE 
  THRU DEC  31
     (WD) (1,24) VALUES = 
       (0, 0, 0, 0, 0, 0, 1, 1, 
        1, 1, 1, 1, 1, 1, 1, 1, 
        1, 1, 0, 0, 0, 0, 0, 0)
     (WEH) (1,24) VALUES = 
       (0)
   .. 
  HeatOSSCH4  SCHEDULE 
  THRU DEC  31
     (WD) (1,24) VALUES = 
       (0, 0, 0, 0, 0, 0, 1, 1, 
        1, 1, 1, 1, 1, 1, 1, 1, 
        1, 1, 0, 0, 0, 0, 0, 0)
     (WEH) (1,24) VALUES = 
       (0)
   .. 
  HeatOSSCH5  SCHEDULE 
  THRU DEC  31
     (WD) (1,24) VALUES = 
       (0, 0, 0, 0, 0, 0, 1, 1, 
        1, 1, 1, 1, 1, 1, 1, 1, 
        1, 1, 0, 0, 0, 0, 0, 0)
     (WEH) (1,24) VALUES = 
       (0)
   .. 

$ ********** µÚ  1 ¸öÏµÍ³ **********
sys1=SYSTEM SYSTEM-TYPE=PTAC HEAT-SOURCE=HEAT-PUMP
  MAX-SUPPLY-T=40 MIN-SUPPLY-T=12.8
  HEATING-SCHEDULE=HeatOSSCH4 COOLING-SCHEDULE=CoolOSSCH4
  ZONE-NAMES=(RM02050,RM02049,RM02048,RM01053,RM01003,RM01052
             ,RM01031,RM01025,RM01042,RM01039,RM02052,RM03010
             ,RM03020,RM03005,RM03015,RM03029,RM03062,RM03049
             ,RM03052,RM03054,RM03056,RM03064,RM03055,RM03053) ..
$ ********** µÚ  2 ¸öÏµÍ³ **********
sys2=SYSTEM SYSTEM-TYPE=SUM
  ZONE-NAMES=(RM01007,RM01006,RM01005,RM01008,RM01009,RM01004
             ,RM01001,RM01002,RM01010,RM01011,RM01017,RM01016
             ,RM01012,RM01018,RM01019,RM01013,RM01022,RM01015
             ,RM01021,RM01023,RM01014,RM01020,RM01024,RM01030
             ,RM01028,RM01029,RM01036,RM01027,RM01033,RM01035
             ,RM01032,RM01034,RM01026,RM01045,RM01044,RM01048
             ,RM01049,RM01040,RM01047,RM01046,RM01043,RM01037
             ,RM01038,RM01041,RM01051,RM01050,RM02001,RM02002
             ,RM02009,RM02006,RM02014,RM02012,RM02004,RM02013
             ,RM02015,RM02010,RM02003,RM02005,RM02007,RM02008
             ,RM02011,RM02016,RM02019,RM02017,RM02023,RM02021
             ,RM02028,RM02027,RM02022,RM02024,RM02025,RM02020
             ,RM02026,RM02018,RM02036,RM02040,RM02038,RM02029
             ,RM02034,RM02037,RM02035,RM02039,RM02030,RM02032
             ,RM02031,RM02033,RM02043,RM02051,RM02044,RM02045
             ,RM02047,RM02041,RM02046,RM02042,RM03007,RM03008
             ,RM03006,RM03002,RM03009,RM03003,RM03004,RM03001
             ,RM03018,RM03014,RM03011,RM03017,RM03012,RM03016
             ,RM03019,RM03021,RM03013,RM03023,RM03024,RM03022
             ,RM03028,RM03031,RM03025,RM03032,RM03033,RM03026
             ,RM03030,RM03027,RM03045,RM03041,RM03046,RM03038
             ,RM03039,RM03035,RM03043,RM03036,RM03042,RM03037
             ,RM03044,RM03034,RM03040,RM03050,RM03048,RM03051
             ,RM03057,RM03058,RM03047,RM03069,RM03066,RM03061
             ,RM03059,RM03063,RM03060,RM03065,RM03067,RM03068) ..

PLT-P PLANT-ASSIGNMENT SYSTEM-NAMES
 (sys1,sys2) ..
SYSTEMS-REPORT S (SS-A,SS-B,SS-C,SS-D,SS-E,SS-F,SS-G) ..



 $ ÏµÍ³ÖðÊ±¸ººÉ±¨¸æÊé 
HRSYSSCH=SCHEDULE  THRU DEC 31 (ALL) (1,24) VALUES=(1)   ..
DBSS0  REPORT-BLOCK  VARIABLE-TYPE=GLOBAL
VARIABLE-LIST=(8,10,7) ..
HRPsys0  HOURLY-REPORT  REPORT-SCHEDULE=HRSYSSCH R-B=(DBSS0) ..
DBSS1  REPORT-BLOCK  VARIABLE-TYPE=sys1
          VARIABLE-LIST=(7,8,48) ..
HRPsys1  HOURLY-REPORT  REPORT-SCHEDULE=HRSYSSCH R-B=(DBSS1) ..

DBSS2  REPORT-BLOCK  VARIABLE-TYPE=sys2
          VARIABLE-LIST=(6,7,48) ..
HRPsys2  HOURLY-REPORT  REPORT-SCHEDULE=HRSYSSCH R-B=(DBSS2) ..


END ..
COMPUTE SYSTEMS ..

INPUT PLANT  OUTPUT-UNITS METRIC ..
TITLE  LINE-1 *PLANT RUN1* ..
PLT-P  PLANT-ASSIGNMENT ..
CLG P-E TYPE HERM-CENT-CHLR SIZE -999 I-N 1 ..
HLG P-E TYPE HW-BOILER SIZE -999 I-N 1 ..
ENERGY-RESOURCE RESOURCE NATURAL-GAS  ..
PART-LOAD-RATIO TYPE HERM-CENT-CHLR E-I-R 0.33  ..
ENERGY-RESOURCE RESOURCE ELECTRICITY ..

PLANT-REPORT 
S (ALL-SUMMARY) ..
HrSchHv1 = SCHEDULE
  THRU DEC 31 (ALL) (1,24) VALUES=(1)   .. 
  HrDbHv1 = REPORT-BLOCK  
  V-T = END-USE
  V-L = (1,2,3,5,6,7,8,9,15,16)  ..
  HrRepHv1 = HOURLY-REPORT  
  REPORT-SCHEDULE=HrSchHv1
  R-B=(HrDbHv1) ..

END  ..
COMPUTE PLANT  ..

STOP  ..
